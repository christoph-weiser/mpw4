* SPICE3 file created from user_analog_project_wrapper.ext - technology: sky130A

.subckt md__cdec VSUBS m3_n1050_n1300# c1_n950_n1200#
X0 c1_n950_n1200# m3_n1050_n1300# sky130_fd_pr__cap_mim_m3_1 l=1.2e+07u w=9e+06u
.ends

.subckt module_decap VSUBS m3_0_0# m3_0_380#
Xmd__cdec_0 VSUBS m3_0_380# m3_0_0# md__cdec
Xmd__cdec_2 VSUBS m3_0_380# m3_0_0# md__cdec
Xmd__cdec_1 VSUBS m3_0_380# m3_0_0# md__cdec
.ends

.subckt inv_MP VSUBS
X0 a_40_n64# a_n40_n161# a_n98_n64# w_n236_n284# sky130_fd_pr__pfet_01v8_lvt ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=400000u
.ends

.subckt inv_MN VSUBS w_n226_n269# a_n98_n131# a_n40_n157# a_40_n131#
X0 a_40_n131# a_n40_n157# a_n98_n131# VSUBS sky130_fd_pr__nfet_01v8_lvt ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=400000u
.ends

.subckt inverter VSUBS m2_0_899# m2_0_214# m1_0_545# m2_289_297#
Xinv_MP_0 VSUBS inv_MP
Xinv_MN_0 VSUBS m2_0_214# m2_0_214# m1_0_545# m2_289_297# inv_MN
.ends

.subckt bbp__M5 VSUBS a_n108_n100# a_n50_n126# a_50_n100# w_n144_n162#
X0 a_50_n100# a_n50_n126# a_n108_n100# w_n144_n162# sky130_fd_pr__pfet_01v8_lvt ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
.ends

.subckt bbp__M6 VSUBS a_n108_n100# a_n50_n126# a_50_n100# w_n144_n162#
X0 a_50_n100# a_n50_n126# a_n108_n100# w_n144_n162# sky130_fd_pr__pfet_01v8_lvt ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
.ends

.subckt bbp__M4 VSUBS a_n108_n100# a_n50_n126# a_50_n100# w_n144_n162#
X0 a_50_n100# a_n50_n126# a_n108_n100# w_n144_n162# sky130_fd_pr__pfet_01v8_lvt ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
.ends

.subckt bbp__DUM VSUBS a_n108_n100# a_n50_n126# a_50_n100# w_n144_n162#
X0 a_50_n100# a_n50_n126# a_n108_n100# w_n144_n162# sky130_fd_pr__pfet_01v8_lvt ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
.ends

.subckt bb_pmirr VSUBS m2_133_674# m2_219_0# w_46_70# m3_2424_881#
Xbbp__M5_2 VSUBS m2_219_0# a_673_660# w_46_70# w_46_70# bbp__M5
Xbbp__M5_3 VSUBS w_46_70# a_831_660# m2_219_0# w_46_70# bbp__M5
Xbbp__M5_4 VSUBS m2_219_0# a_673_660# w_46_70# w_46_70# bbp__M5
Xbbp__M5_5 VSUBS w_46_70# a_831_660# m2_219_0# w_46_70# bbp__M5
Xbbp__M5_6 VSUBS w_46_70# a_1779_660# m2_219_0# w_46_70# bbp__M5
Xbbp__M5_7 VSUBS m2_219_0# a_1621_660# w_46_70# w_46_70# bbp__M5
Xbbp__M5_8 VSUBS w_46_70# a_1779_660# m2_219_0# w_46_70# bbp__M5
Xbbp__M6_0 VSUBS m3_2424_881# a_1147_660# w_46_70# w_46_70# bbp__M6
Xbbp__M6_1 VSUBS w_46_70# a_1305_660# m3_2424_881# w_46_70# bbp__M6
Xbbp__M4_0 VSUBS m2_133_674# a_1147_660# w_46_70# w_46_70# bbp__M4
Xbbp__M4_1 VSUBS w_46_70# a_1305_660# m2_133_674# w_46_70# bbp__M4
Xbbp__M4_2 VSUBS m2_133_674# a_673_660# w_46_70# w_46_70# bbp__M4
Xbbp__M4_3 VSUBS w_46_70# a_831_660# m2_133_674# w_46_70# bbp__M4
Xbbp__M4_4 VSUBS m2_133_674# a_1621_660# w_46_70# w_46_70# bbp__M4
Xbbp__M4_5 VSUBS w_46_70# a_1305_660# m2_133_674# w_46_70# bbp__M4
Xbbp__M4_6 VSUBS w_46_70# a_1779_660# m2_133_674# w_46_70# bbp__M4
Xbbp__DUM_0 VSUBS m2_219_0# a_2095_660# m2_219_0# w_46_70# bbp__DUM
Xbbp__M4_7 VSUBS m2_133_674# a_1147_660# w_46_70# w_46_70# bbp__M4
Xbbp__DUM_1 VSUBS m2_219_0# a_357_660# m2_219_0# w_46_70# bbp__DUM
Xbbp__DUM_2 VSUBS m2_219_0# a_357_660# m2_219_0# w_46_70# bbp__DUM
Xbbp__DUM_3 VSUBS m2_219_0# a_2095_660# m2_219_0# w_46_70# bbp__DUM
Xbbp__DUM_4 VSUBS m2_219_0# a_357_660# m2_219_0# w_46_70# bbp__DUM
Xbbp__DUM_5 VSUBS m2_219_0# a_2095_660# m2_219_0# w_46_70# bbp__DUM
Xbbp__M5_0 VSUBS m2_219_0# a_1621_660# w_46_70# w_46_70# bbp__M5
Xbbp__M5_1 VSUBS w_46_70# a_1779_660# m2_219_0# w_46_70# bbp__M5
.ends

.subckt bbn__M2 VSUBS a_n108_n100# a_n50_n126# a_50_n100#
X0 a_50_n100# a_n50_n126# a_n108_n100# VSUBS sky130_fd_pr__nfet_01v8_lvt ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
.ends

.subckt bbn__M3 VSUBS a_n108_n100# a_n50_n126# a_50_n100#
X0 a_50_n100# a_n50_n126# a_n108_n100# VSUBS sky130_fd_pr__nfet_01v8_lvt ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
.ends

.subckt bbn__M1 VSUBS a_n108_n100# a_n50_n126# a_50_n100#
X0 a_50_n100# a_n50_n126# a_n108_n100# VSUBS sky130_fd_pr__nfet_01v8_lvt ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
.ends

.subckt bb__nmirr VSUBS m2_254_316# m1_327_628# m2_134_0# m3_1312_1446# m2_96_3050#
Xbbn__M2_30 VSUBS m2_254_316# m1_327_628# m2_96_3050# bbn__M2
Xbbn__M3_0 VSUBS m2_134_0# m1_327_628# m3_1312_1446# bbn__M3
Xbbn__M2_31 VSUBS m2_254_316# m1_327_628# m2_96_3050# bbn__M2
Xbbn__M2_20 VSUBS m2_254_316# m1_327_628# m2_96_3050# bbn__M2
Xbbn__M3_1 VSUBS m2_134_0# m1_327_628# m3_1312_1446# bbn__M3
Xbbn__M2_21 VSUBS m2_254_316# m1_327_628# m2_96_3050# bbn__M2
Xbbn__M2_10 VSUBS m2_254_316# m1_327_628# m2_96_3050# bbn__M2
Xbbn__M2_22 VSUBS m2_254_316# m1_327_628# m2_96_3050# bbn__M2
Xbbn__M2_11 VSUBS m2_254_316# m1_327_628# m2_96_3050# bbn__M2
Xbbn__M2_23 VSUBS m2_254_316# m1_327_628# m2_96_3050# bbn__M2
Xbbn__M1_0 VSUBS m2_134_0# m1_327_628# m1_327_628# bbn__M1
Xbbn__M2_12 VSUBS m2_254_316# m1_327_628# m2_96_3050# bbn__M2
Xbbn__M1_1 VSUBS m2_134_0# m1_327_628# m1_327_628# bbn__M1
Xbbn__M2_24 VSUBS m2_254_316# m1_327_628# m2_96_3050# bbn__M2
Xbbn__M2_13 VSUBS m2_254_316# m1_327_628# m2_96_3050# bbn__M2
Xbbn__M2_25 VSUBS m2_254_316# m1_327_628# m2_96_3050# bbn__M2
Xbbn__M1_2 VSUBS m2_134_0# m1_327_628# m1_327_628# bbn__M1
Xbbn__M2_14 VSUBS m2_254_316# m1_327_628# m2_96_3050# bbn__M2
Xbbn__M1_3 VSUBS m2_134_0# m1_327_628# m1_327_628# bbn__M1
Xbbn__M2_26 VSUBS m2_254_316# m1_327_628# m2_96_3050# bbn__M2
Xbbn__M2_15 VSUBS m2_254_316# m1_327_628# m2_96_3050# bbn__M2
Xbbn__M2_27 VSUBS m2_254_316# m1_327_628# m2_96_3050# bbn__M2
Xbbn__M2_16 VSUBS m2_254_316# m1_327_628# m2_96_3050# bbn__M2
Xbbn__M1_4 VSUBS m2_134_0# m1_327_628# m1_327_628# bbn__M1
Xbbn__M1_5 VSUBS m2_134_0# m1_327_628# m1_327_628# bbn__M1
Xbbn__M2_28 VSUBS m2_254_316# m1_327_628# m2_96_3050# bbn__M2
Xbbn__M2_17 VSUBS m2_254_316# m1_327_628# m2_96_3050# bbn__M2
Xbbn__M1_6 VSUBS m2_134_0# m1_327_628# m1_327_628# bbn__M1
Xbbn__M2_29 VSUBS m2_254_316# m1_327_628# m2_96_3050# bbn__M2
Xbbn__M2_18 VSUBS m2_254_316# m1_327_628# m2_96_3050# bbn__M2
Xbbn__M1_7 VSUBS m2_134_0# m1_327_628# m1_327_628# bbn__M1
Xbbn__M2_19 VSUBS m2_254_316# m1_327_628# m2_96_3050# bbn__M2
Xbbn__M2_0 VSUBS m2_254_316# m1_327_628# m2_96_3050# bbn__M2
Xbbn__M2_1 VSUBS m2_254_316# m1_327_628# m2_96_3050# bbn__M2
Xbbn__M2_2 VSUBS m2_254_316# m1_327_628# m2_96_3050# bbn__M2
Xbbn__M2_3 VSUBS m2_254_316# m1_327_628# m2_96_3050# bbn__M2
Xbbn__M2_4 VSUBS m2_254_316# m1_327_628# m2_96_3050# bbn__M2
Xbbn__M2_5 VSUBS m2_254_316# m1_327_628# m2_96_3050# bbn__M2
Xbbn__M2_6 VSUBS m2_254_316# m1_327_628# m2_96_3050# bbn__M2
Xbbn__M2_7 VSUBS m2_254_316# m1_327_628# m2_96_3050# bbn__M2
Xbbn__M2_8 VSUBS m2_254_316# m1_327_628# m2_96_3050# bbn__M2
Xbbn__M2_9 VSUBS m2_254_316# m1_327_628# m2_96_3050# bbn__M2
.ends

.subckt bb__M10 VSUBS a_100_n86# w_n194_n148# a_n158_n86# a_n100_n112#
X0 a_100_n86# a_n100_n112# a_n158_n86# w_n194_n148# sky130_fd_pr__pfet_01v8_lvt ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=1e+06u
.ends

.subckt bb__M9 VSUBS a_100_n86# w_n194_n148# a_n158_n86# a_n100_n112#
X0 a_100_n86# a_n100_n112# a_n158_n86# w_n194_n148# sky130_fd_pr__pfet_01v8_lvt ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=1e+06u
.ends

.subckt bb__R1 VSUBS a_n194_850# a_n194_n1282# a_124_850# a_124_n1282#
X0 a_n194_n1282# a_n194_850# VSUBS sky130_fd_pr__res_xhigh_po w=350000u l=8.5e+06u
X1 a_124_n1282# a_124_850# VSUBS sky130_fd_pr__res_xhigh_po w=350000u l=8.5e+06u
.ends

.subckt bb__M7 VSUBS a_n88_n131# a_30_n131# a_n33_91#
X0 a_30_n131# a_n33_91# a_n88_n131# VSUBS sky130_fd_pr__nfet_01v8_lvt ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=300000u
.ends

.subckt bb__R2 VSUBS a_n194_850# a_n194_n1282# a_124_850# a_124_n1282#
X0 a_n194_n1282# a_n194_850# VSUBS sky130_fd_pr__res_xhigh_po w=350000u l=8.5e+06u
X1 a_124_n1282# a_124_850# VSUBS sky130_fd_pr__res_xhigh_po w=350000u l=8.5e+06u
.ends

.subckt bb__M8 VSUBS a_n88_n131# a_30_n131# a_n33_91#
X0 a_30_n131# a_n33_91# a_n88_n131# VSUBS sky130_fd_pr__nfet_01v8_lvt ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=300000u
.ends

.subckt bias_basis_current VSUBS m3_0_0# m3_0_380# m3_4204_5508# m3_4273_3065#
Xbb_pmirr_0 VSUBS m1_711_3747# m2_1682_4603# m3_0_0# m3_4204_5508# bb_pmirr
Xbb__nmirr_0 VSUBS m2_3967_1509# m1_711_3747# m3_0_380# m3_4273_3065# m2_1682_4603#
+ bb__nmirr
Xbb__M10_0 VSUBS m2_490_5152# m3_0_0# m2_97_3643# m2_490_5152# bb__M10
Xbb__M9_0 VSUBS m1_807_5168# m3_0_0# m2_490_5152# m1_807_5168# bb__M9
Xbb__R1_0 VSUBS m2_3967_1509# m1_1634_859# m3_0_380# m1_1634_859# bb__R1
Xbb__M7_0 VSUBS m3_0_380# m1_807_5168# m1_807_5168# bb__M7
Xbb__R2_0 VSUBS m1_322_845# m3_0_0# m1_322_845# m2_97_3643# bb__R2
Xbb__M8_0 VSUBS m1_711_3747# m3_0_0# m1_807_5168# bb__M8
.ends

.subckt bg__M2 VSUBS a_n50_n112# a_50_n86# w_n144_n148# a_n108_n86#
X0 a_50_n86# a_n50_n112# a_n108_n86# w_n144_n148# sky130_fd_pr__pfet_01v8 ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=500000u
.ends

.subckt bgr_unit VSUBS a_n69_1800# a_n69_n2232#
X0 a_n69_n2232# a_n69_1800# VSUBS sky130_fd_pr__res_xhigh_po w=690000u l=1.8e+07u
.ends

.subckt bg__res VSUBS m1_5976_4850# m1_912_169# m1_3856_383# m1_490_169# m1_6398_4850#
+ bgr_unit_1/a_n69_1800# bgr_unit_0/a_n69_1800# m1_3866_4850#
Xbgr_unit_10 VSUBS m1_2600_4850# m1_3022_n43# bgr_unit
Xbgr_unit_11 VSUBS m1_2600_4850# m1_1334_n43# bgr_unit
Xbgr_unit_12 VSUBS m1_2178_4850# m1_1756_169# bgr_unit
Xbgr_unit_13 VSUBS m1_490_4850# m1_1756_169# bgr_unit
Xbgr_unit_14 VSUBS m1_912_4850# m1_1334_n43# bgr_unit
Xbgr_unit_16 VSUBS m1_490_4850# m1_490_169# bgr_unit
Xbgr_unit_15 VSUBS m1_912_4850# m1_912_169# bgr_unit
Xbgr_unit_0 VSUBS bgr_unit_0/a_n69_1800# bgr_unit_0/a_n69_n2232# bgr_unit
Xbgr_unit_1 VSUBS bgr_unit_1/a_n69_1800# bgr_unit_1/a_n69_n2232# bgr_unit
Xbgr_unit_2 VSUBS m1_6398_4850# m1_5132_n43# bgr_unit
Xbgr_unit_3 VSUBS m1_5976_4850# m1_5554_169# bgr_unit
Xbgr_unit_4 VSUBS m1_4288_4850# m1_5554_169# bgr_unit
Xbgr_unit_5 VSUBS m1_4710_4850# m1_5132_n43# bgr_unit
Xbgr_unit_6 VSUBS m1_4710_4850# m1_3022_n43# bgr_unit
Xbgr_unit_7 VSUBS m1_4288_4850# m1_3444_169# bgr_unit
Xbgr_unit_9 VSUBS m1_2178_4850# m1_3444_169# bgr_unit
Xbgr_unit_8 VSUBS m1_3866_4850# m1_3856_383# bgr_unit
.ends

.subckt bg__M1 VSUBS a_n50_n112# a_50_n86# w_n144_n148# a_n108_n86#
X0 a_50_n86# a_n50_n112# a_n108_n86# w_n144_n148# sky130_fd_pr__pfet_01v8 ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=500000u
.ends

.subckt bgpg__pnp VSUBS a_330_330# w_0_0# w_153_153#
X0 a_330_330# w_153_153# VSUBS sky130_fd_pr__pnp_05v0 area=4.624e+11p
.ends

.subckt bg__pnp_group VSUBS m1_1644_1644# m1_314_314# m1_900_900# m1_42_42#
Xbgpg__pnp_0 VSUBS m1_900_900# m1_314_314# m1_314_314# bgpg__pnp
Xbgpg__pnp_1 VSUBS m1_900_900# m1_314_314# m1_314_314# bgpg__pnp
Xbgpg__pnp_2 VSUBS m1_900_900# m1_314_314# m1_314_314# bgpg__pnp
Xbgpg__pnp_3 VSUBS m1_900_900# m1_314_314# m1_314_314# bgpg__pnp
Xbgpg__pnp_4 VSUBS m1_900_900# m1_314_314# m1_314_314# bgpg__pnp
Xbgpg__pnp_5 VSUBS m1_900_900# m1_314_314# m1_314_314# bgpg__pnp
Xbgpg__pnp_6 VSUBS m1_1644_1644# m1_314_314# m1_314_314# bgpg__pnp
Xbgpg__pnp_7 VSUBS m1_900_900# m1_314_314# m1_314_314# bgpg__pnp
Xbgpg__pnp_8 VSUBS m1_900_900# m1_314_314# m1_314_314# bgpg__pnp
.ends

.subckt bga__M2 VSUBS w_n894_n198# a_n800_n162# a_n858_n136# a_800_n136#
X0 a_800_n136# a_n800_n162# a_n858_n136# w_n894_n198# sky130_fd_pr__pfet_01v8_lvt ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=8e+06u
.ends

.subckt bga__DUM3 VSUBS w_n884_n157# a_n858_n131# a_n800_n157# a_800_n131#
X0 a_800_n131# a_n800_n157# a_n858_n131# VSUBS sky130_fd_pr__nfet_01v8_lvt ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=8e+06u
.ends

.subckt bga__DUM1 VSUBS w_n194_n298# a_n100_n262# a_n158_n236# a_100_n236#
X0 a_100_n236# a_n100_n262# a_n158_n236# w_n194_n298# sky130_fd_pr__pfet_01v8_lvt ad=5.8e+11p pd=4.58e+06u as=5.8e+11p ps=4.58e+06u w=2e+06u l=1e+06u
.ends

.subckt bga__M5 VSUBS w_n194_n298# a_n100_n262# a_n158_n236# a_100_n236#
X0 a_100_n236# a_n100_n262# a_n158_n236# w_n194_n298# sky130_fd_pr__pfet_01v8_lvt ad=5.8e+11p pd=4.58e+06u as=5.8e+11p ps=4.58e+06u w=2e+06u l=1e+06u
.ends

.subckt bga__M3 VSUBS w_n884_n157# a_n858_n131# a_n800_n157# a_800_n131#
X0 a_800_n131# a_n800_n157# a_n858_n131# VSUBS sky130_fd_pr__nfet_01v8_lvt ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=8e+06u
.ends

.subckt bga__M1 VSUBS w_n894_n198# a_n800_n162# a_n858_n136# a_800_n136#
X0 a_800_n136# a_n800_n162# a_n858_n136# w_n894_n198# sky130_fd_pr__pfet_01v8_lvt ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=8e+06u
.ends

.subckt bga__DUM2 VSUBS w_n894_n198# a_n800_n162# a_n858_n136# a_800_n136#
X0 a_800_n136# a_n800_n162# a_n858_n136# w_n894_n198# sky130_fd_pr__pfet_01v8_lvt ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=8e+06u
.ends

.subckt bga__M6 VSUBS w_n194_n298# a_n100_n262# a_n158_n236# a_100_n236#
X0 a_100_n236# a_n100_n262# a_n158_n236# w_n194_n298# sky130_fd_pr__pfet_01v8_lvt ad=5.8e+11p pd=4.58e+06u as=5.8e+11p ps=4.58e+06u w=2e+06u l=1e+06u
.ends

.subckt bga__M4 VSUBS w_n884_n157# a_n858_n131# a_n800_n157# a_800_n131#
X0 a_800_n131# a_n800_n157# a_n858_n131# VSUBS sky130_fd_pr__nfet_01v8_lvt ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=8e+06u
.ends

.subckt bg__amplifier VSUBS m3_0_380# m3_0_0# m3_6771_2313# m3_6341_2931# m2_0_5342#
+ m3_5757_2931#
Xbga__M2_0 VSUBS m3_0_0# m3_6341_2931# m1_5227_2697# m3_6771_2313# bga__M2
Xbga__M2_1 VSUBS m3_0_0# m3_6341_2931# m1_5227_2697# m3_6771_2313# bga__M2
Xbga__M2_2 VSUBS m3_0_0# m3_6341_2931# m3_6771_2313# m1_5227_2697# bga__M2
Xbga__M2_3 VSUBS m3_0_0# m3_6341_2931# m3_6771_2313# m1_5227_2697# bga__M2
Xbga__DUM3_0 VSUBS bga__M4_1/w_n884_n157# m2_4069_1802# m3_0_380# m3_0_380# bga__DUM3
Xbga__DUM3_1 VSUBS bga__M4_0/w_n884_n157# m3_6771_2313# m3_0_380# m3_0_380# bga__DUM3
Xbga__DUM3_2 VSUBS bga__M4_1/w_n884_n157# m3_0_380# m3_0_380# m3_6771_2313# bga__DUM3
Xbga__DUM3_3 VSUBS bga__M4_0/w_n884_n157# m3_0_380# m3_0_380# m2_4069_1802# bga__DUM3
Xbga__DUM1_0 VSUBS m3_0_0# m3_0_0# m3_0_0# m3_0_0# bga__DUM1
Xbga__DUM1_1 VSUBS m3_0_0# m3_0_0# m3_0_0# m3_0_0# bga__DUM1
Xbga__M5_0 VSUBS m3_0_0# m2_0_5342# m1_5227_2697# m3_0_0# bga__M5
Xbga__M5_1 VSUBS m3_0_0# m2_0_5342# m3_0_0# m1_5227_2697# bga__M5
Xbga__M3_0 VSUBS bga__M4_1/w_n884_n157# m3_0_380# m2_4069_1802# m2_4069_1802# bga__M3
Xbga__M3_1 VSUBS bga__M4_0/w_n884_n157# m2_4069_1802# m2_4069_1802# m3_0_380# bga__M3
Xbga__M1_0 VSUBS m3_0_0# m3_5757_2931# m1_5227_2697# m2_4069_1802# bga__M1
Xbga__M1_1 VSUBS m3_0_0# m3_5757_2931# m1_5227_2697# m2_4069_1802# bga__M1
Xbga__M1_2 VSUBS m3_0_0# m3_5757_2931# m2_4069_1802# m1_5227_2697# bga__M1
Xbga__M1_3 VSUBS m3_0_0# m3_5757_2931# m2_4069_1802# m1_5227_2697# bga__M1
Xbga__DUM2_0 VSUBS m3_0_0# m3_0_0# m3_0_0# m2_4069_1802# bga__DUM2
Xbga__DUM2_1 VSUBS m3_0_0# m3_0_0# m3_0_0# m2_4069_1802# bga__DUM2
Xbga__DUM2_2 VSUBS m3_0_0# m3_0_0# m3_0_0# m3_6771_2313# bga__DUM2
Xbga__DUM2_3 VSUBS m3_0_0# m3_0_0# m2_4069_1802# m3_0_0# bga__DUM2
Xbga__DUM2_4 VSUBS m3_0_0# m3_0_0# m3_6771_2313# m3_0_0# bga__DUM2
Xbga__DUM2_5 VSUBS m3_0_0# m3_0_0# m3_6771_2313# m3_0_0# bga__DUM2
Xbga__M6_0 VSUBS m3_0_0# m2_0_5342# m3_0_0# m2_0_5342# bga__M6
Xbga__DUM2_6 VSUBS m3_0_0# m3_0_0# m2_4069_1802# m3_0_0# bga__DUM2
Xbga__M6_1 VSUBS m3_0_0# m2_0_5342# m2_0_5342# m3_0_0# bga__M6
Xbga__DUM2_7 VSUBS m3_0_0# m3_0_0# m3_0_0# m3_6771_2313# bga__DUM2
Xbga__M6_2 VSUBS m3_0_0# m2_0_5342# m3_0_0# m2_0_5342# bga__M6
Xbga__M6_3 VSUBS m3_0_0# m2_0_5342# m2_0_5342# m3_0_0# bga__M6
Xbga__M4_0 VSUBS bga__M4_0/w_n884_n157# m3_0_380# m2_4069_1802# m3_6771_2313# bga__M4
Xbga__M4_1 VSUBS bga__M4_1/w_n884_n157# m3_6771_2313# m2_4069_1802# m3_0_380# bga__M4
.ends

.subckt bgc_unit VSUBS m3_n1150_n1100# c1_n1050_n1000#
X0 c1_n1050_n1000# m3_n1150_n1100# sky130_fd_pr__cap_mim_m3_1 l=1e+07u w=1e+07u
.ends

.subckt bg__cap VSUBS m4_0_1061# m4_2493_12#
Xbgc_unit_1 VSUBS m4_2493_12# m4_0_1061# bgc_unit
Xbgc_unit_3 VSUBS m4_2493_12# m4_0_1061# bgc_unit
Xbgc_unit_2 VSUBS m4_2493_12# m4_0_1061# bgc_unit
Xbgc_unit_0 VSUBS m4_2493_12# m4_0_1061# bgc_unit
.ends

.subckt bandgap VSUBS m3_0_0# m4_n65_9016# m3_14333_882# m3_0_5342#
Xbg__M2_1 VSUBS m3_8602_5959# m3_14333_882# m3_0_0# m3_0_0# bg__M2
Xbg__res_0 VSUBS m2_10413_1144# m2_9497_4459# m2_9497_4459# m2_9497_4259# m3_14333_882#
+ m4_n65_9016# m4_n65_9016# m2_11672_6286# bg__res
Xbg__M1_1 VSUBS m3_8602_5959# m3_0_0# m3_0_0# m2_10413_1144# bg__M1
Xbg__M1_0 VSUBS m3_8602_5959# m2_10413_1144# m3_0_0# m3_0_0# bg__M1
Xbg__pnp_group_0 VSUBS m2_9497_4259# m4_n65_9016# m2_11672_6286# m3_0_0# bg__pnp_group
Xbg__amplifier_0 VSUBS m4_n65_9016# m3_0_0# m3_8602_5959# m2_9497_4259# m3_0_5342#
+ m2_9497_4459# bg__amplifier
Xbg__cap_0 VSUBS m3_8602_5959# m4_n65_9016# bg__cap
Xbg__M2_0 VSUBS m3_8602_5959# m3_0_0# m3_0_0# m3_14333_882# bg__M2
.ends

.subckt reg__M8 VSUBS a_n40_n162# a_n98_n136# w_n236_n284# a_40_n136#
X0 a_40_n136# a_n40_n162# a_n98_n136# w_n236_n284# sky130_fd_pr__pfet_01v8_lvt ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=400000u
.ends

.subckt regdp__M1 VSUBS a_n158_n131# a_n100_n157# a_100_n131# w_n184_n157#
X0 a_100_n131# a_n100_n157# a_n158_n131# VSUBS sky130_fd_pr__nfet_01v8_lvt ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=1e+06u
.ends

.subckt regdp__M2 VSUBS a_n158_n131# a_n100_n157# a_100_n131# w_n184_n157#
X0 a_100_n131# a_n100_n157# a_n158_n131# VSUBS sky130_fd_pr__nfet_01v8_lvt ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=1e+06u
.ends

.subckt regdp__DUM VSUBS a_n158_n131# a_n100_n157# a_100_n131# w_n184_n157#
X0 a_100_n131# a_n100_n157# a_n158_n131# VSUBS sky130_fd_pr__nfet_01v8_lvt ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=1e+06u
.ends

.subckt reg__diffpair VSUBS m2_0_898# m3_486_473# m2_0_1335# m3_1220_10# m2_0_459#
+ m1_436_322#
Xregdp__M1_0 VSUBS m3_486_473# m2_0_1335# m2_0_898# regdp__M2_3/w_n184_n157# regdp__M1
Xregdp__M1_1 VSUBS m2_0_898# m2_0_1335# m3_486_473# regdp__M2_3/w_n184_n157# regdp__M1
Xregdp__M1_2 VSUBS m3_486_473# m2_0_1335# m2_0_898# regdp__M2_7/w_n184_n157# regdp__M1
Xregdp__M1_3 VSUBS m2_0_898# m2_0_1335# m3_486_473# regdp__M2_7/w_n184_n157# regdp__M1
Xregdp__M1_4 VSUBS m3_486_473# m2_0_1335# m2_0_898# regdp__M2_7/w_n184_n157# regdp__M1
Xregdp__M1_5 VSUBS m2_0_898# m2_0_1335# m3_486_473# regdp__M2_7/w_n184_n157# regdp__M1
Xregdp__M1_6 VSUBS m2_0_898# m2_0_1335# m3_486_473# regdp__M2_3/w_n184_n157# regdp__M1
Xregdp__M1_7 VSUBS m3_486_473# m2_0_1335# m2_0_898# regdp__M2_3/w_n184_n157# regdp__M1
Xregdp__M2_0 VSUBS m3_1220_10# m2_0_459# m2_0_898# regdp__M2_3/w_n184_n157# regdp__M2
Xregdp__DUM_0 VSUBS m3_486_473# m3_486_473# m3_486_473# regdp__M2_3/w_n184_n157# regdp__DUM
Xregdp__M2_1 VSUBS m2_0_898# m2_0_459# m3_1220_10# regdp__M2_3/w_n184_n157# regdp__M2
Xregdp__DUM_1 VSUBS m3_486_473# m3_486_473# m3_486_473# regdp__M2_3/w_n184_n157# regdp__DUM
Xregdp__M2_2 VSUBS m2_0_898# m2_0_459# m3_1220_10# regdp__M2_3/w_n184_n157# regdp__M2
Xregdp__DUM_2 VSUBS m3_1220_10# m3_1220_10# m3_1220_10# regdp__M2_7/w_n184_n157# regdp__DUM
Xregdp__M2_3 VSUBS m3_1220_10# m2_0_459# m2_0_898# regdp__M2_3/w_n184_n157# regdp__M2
Xregdp__DUM_3 VSUBS m3_1220_10# m3_1220_10# m3_1220_10# regdp__M2_7/w_n184_n157# regdp__DUM
Xregdp__M2_4 VSUBS m3_1220_10# m2_0_459# m2_0_898# regdp__M2_7/w_n184_n157# regdp__M2
Xregdp__M2_5 VSUBS m2_0_898# m2_0_459# m3_1220_10# regdp__M2_7/w_n184_n157# regdp__M2
Xregdp__M2_6 VSUBS m3_1220_10# m2_0_459# m2_0_898# regdp__M2_7/w_n184_n157# regdp__M2
Xregdp__M2_7 VSUBS m2_0_898# m2_0_459# m3_1220_10# regdp__M2_7/w_n184_n157# regdp__M2
.ends

.subckt reg__M7 VSUBS a_50_n836# w_n144_n898# a_n50_n862# a_n108_n836#
X0 a_50_n836# a_n50_n862# a_n108_n836# w_n144_n898# sky130_fd_pr__pfet_01v8_lvt ad=2.32e+12p pd=1.658e+07u as=2.32e+12p ps=1.658e+07u w=8e+06u l=500000u
.ends

.subckt reg__M7_array VSUBS reg__M7_25/a_50_n836# reg__M7_15/a_50_n836# reg__M7_6/a_50_n836#
+ reg__M7_9/w_n144_n898# reg__M7_4/a_50_n836# reg__M7_24/a_50_n836# reg__M7_14/a_50_n836#
+ reg__M7_31/a_n108_n836# reg__M7_23/a_50_n836# reg__M7_13/a_50_n836# reg__M7_19/a_n50_n862#
+ reg__M7_18/a_n50_n862# reg__M7_22/a_50_n836# reg__M7_16/a_n50_n862# reg__M7_17/a_n50_n862#
+ reg__M7_5/a_50_n836# reg__M7_12/a_50_n836# reg__M7_15/a_n50_n862# reg__M7_31/a_50_n836#
+ reg__M7_14/a_n50_n862# reg__M7_21/a_50_n836# reg__M7_12/a_n50_n862# reg__M7_13/a_n50_n862#
+ reg__M7_2/a_50_n836# reg__M7_11/a_50_n836# reg__M7_11/a_n50_n862# reg__M7_30/a_50_n836#
+ reg__M7_10/a_n50_n862# reg__M7_28/a_n50_n862# reg__M7_29/a_n50_n862# reg__M7_20/a_50_n836#
+ reg__M7_8/a_n50_n862# reg__M7_9/a_n50_n862# reg__M7_27/a_n50_n862# reg__M7_1/a_50_n836#
+ reg__M7_10/a_50_n836# reg__M7_7/a_n50_n862# reg__M7_26/a_n50_n862# reg__M7_24/a_n50_n862#
+ reg__M7_25/a_n50_n862# reg__M7_5/a_n50_n862# reg__M7_6/a_n50_n862# reg__M7_23/a_n50_n862#
+ reg__M7_4/a_n50_n862# reg__M7_0/a_50_n836# reg__M7_21/a_n50_n862# reg__M7_22/a_n50_n862#
+ reg__M7_3/a_n50_n862# reg__M7_1/a_n50_n862# reg__M7_2/a_n50_n862# reg__M7_20/a_n50_n862#
+ reg__M7_19/a_50_n836# reg__M7_29/a_50_n836# reg__M7_0/a_n50_n862# reg__M7_18/a_50_n836#
+ reg__M7_28/a_50_n836# reg__M7_9/a_50_n836# reg__M7_27/a_50_n836# reg__M7_31/a_n50_n862#
+ reg__M7_17/a_50_n836# reg__M7_30/a_n50_n862# reg__M7_8/a_50_n836# reg__M7_3/a_50_n836#
+ reg__M7_26/a_50_n836# reg__M7_16/a_50_n836# reg__M7_7/a_50_n836#
Xreg__M7_31 VSUBS reg__M7_31/a_50_n836# reg__M7_9/w_n144_n898# reg__M7_31/a_n50_n862#
+ reg__M7_31/a_n108_n836# reg__M7
Xreg__M7_20 VSUBS reg__M7_20/a_50_n836# reg__M7_9/w_n144_n898# reg__M7_20/a_n50_n862#
+ reg__M7_27/a_50_n836# reg__M7
Xreg__M7_21 VSUBS reg__M7_21/a_50_n836# reg__M7_9/w_n144_n898# reg__M7_21/a_n50_n862#
+ reg__M7_1/a_50_n836# reg__M7
Xreg__M7_10 VSUBS reg__M7_10/a_50_n836# reg__M7_9/w_n144_n898# reg__M7_10/a_n50_n862#
+ reg__M7_17/a_50_n836# reg__M7
Xreg__M7_22 VSUBS reg__M7_22/a_50_n836# reg__M7_9/w_n144_n898# reg__M7_22/a_n50_n862#
+ reg__M7_2/a_50_n836# reg__M7
Xreg__M7_11 VSUBS reg__M7_11/a_50_n836# reg__M7_9/w_n144_n898# reg__M7_11/a_n50_n862#
+ reg__M7_18/a_50_n836# reg__M7
Xreg__M7_23 VSUBS reg__M7_23/a_50_n836# reg__M7_9/w_n144_n898# reg__M7_23/a_n50_n862#
+ reg__M7_3/a_50_n836# reg__M7
Xreg__M7_12 VSUBS reg__M7_12/a_50_n836# reg__M7_9/w_n144_n898# reg__M7_12/a_n50_n862#
+ reg__M7_19/a_50_n836# reg__M7
Xreg__M7_24 VSUBS reg__M7_24/a_50_n836# reg__M7_9/w_n144_n898# reg__M7_24/a_n50_n862#
+ reg__M7_4/a_50_n836# reg__M7
Xreg__M7_13 VSUBS reg__M7_13/a_50_n836# reg__M7_9/w_n144_n898# reg__M7_13/a_n50_n862#
+ reg__M7_20/a_50_n836# reg__M7
Xreg__M7_25 VSUBS reg__M7_25/a_50_n836# reg__M7_9/w_n144_n898# reg__M7_25/a_n50_n862#
+ reg__M7_5/a_50_n836# reg__M7
Xreg__M7_14 VSUBS reg__M7_14/a_50_n836# reg__M7_9/w_n144_n898# reg__M7_14/a_n50_n862#
+ reg__M7_21/a_50_n836# reg__M7
Xreg__M7_26 VSUBS reg__M7_26/a_50_n836# reg__M7_9/w_n144_n898# reg__M7_26/a_n50_n862#
+ reg__M7_6/a_50_n836# reg__M7
Xreg__M7_15 VSUBS reg__M7_15/a_50_n836# reg__M7_9/w_n144_n898# reg__M7_15/a_n50_n862#
+ reg__M7_22/a_50_n836# reg__M7
Xreg__M7_28 VSUBS reg__M7_28/a_50_n836# reg__M7_9/w_n144_n898# reg__M7_28/a_n50_n862#
+ reg__M7_29/a_50_n836# reg__M7
Xreg__M7_27 VSUBS reg__M7_27/a_50_n836# reg__M7_9/w_n144_n898# reg__M7_27/a_n50_n862#
+ reg__M7_28/a_50_n836# reg__M7
Xreg__M7_17 VSUBS reg__M7_17/a_50_n836# reg__M7_9/w_n144_n898# reg__M7_17/a_n50_n862#
+ reg__M7_24/a_50_n836# reg__M7
Xreg__M7_16 VSUBS reg__M7_16/a_50_n836# reg__M7_9/w_n144_n898# reg__M7_16/a_n50_n862#
+ reg__M7_23/a_50_n836# reg__M7
Xreg__M7_29 VSUBS reg__M7_29/a_50_n836# reg__M7_9/w_n144_n898# reg__M7_29/a_n50_n862#
+ reg__M7_30/a_50_n836# reg__M7
Xreg__M7_18 VSUBS reg__M7_18/a_50_n836# reg__M7_9/w_n144_n898# reg__M7_18/a_n50_n862#
+ reg__M7_25/a_50_n836# reg__M7
Xreg__M7_19 VSUBS reg__M7_19/a_50_n836# reg__M7_9/w_n144_n898# reg__M7_19/a_n50_n862#
+ reg__M7_26/a_50_n836# reg__M7
Xreg__M7_0 VSUBS reg__M7_0/a_50_n836# reg__M7_9/w_n144_n898# reg__M7_0/a_n50_n862#
+ reg__M7_7/a_50_n836# reg__M7
Xreg__M7_1 VSUBS reg__M7_1/a_50_n836# reg__M7_9/w_n144_n898# reg__M7_1/a_n50_n862#
+ reg__M7_8/a_50_n836# reg__M7
Xreg__M7_2 VSUBS reg__M7_2/a_50_n836# reg__M7_9/w_n144_n898# reg__M7_2/a_n50_n862#
+ reg__M7_9/a_50_n836# reg__M7
Xreg__M7_4 VSUBS reg__M7_4/a_50_n836# reg__M7_9/w_n144_n898# reg__M7_4/a_n50_n862#
+ reg__M7_11/a_50_n836# reg__M7
Xreg__M7_3 VSUBS reg__M7_3/a_50_n836# reg__M7_9/w_n144_n898# reg__M7_3/a_n50_n862#
+ reg__M7_10/a_50_n836# reg__M7
Xreg__M7_5 VSUBS reg__M7_5/a_50_n836# reg__M7_9/w_n144_n898# reg__M7_5/a_n50_n862#
+ reg__M7_12/a_50_n836# reg__M7
Xreg__M7_6 VSUBS reg__M7_6/a_50_n836# reg__M7_9/w_n144_n898# reg__M7_6/a_n50_n862#
+ reg__M7_13/a_50_n836# reg__M7
Xreg__M7_7 VSUBS reg__M7_7/a_50_n836# reg__M7_9/w_n144_n898# reg__M7_7/a_n50_n862#
+ reg__M7_14/a_50_n836# reg__M7
Xreg__M7_8 VSUBS reg__M7_8/a_50_n836# reg__M7_9/w_n144_n898# reg__M7_8/a_n50_n862#
+ reg__M7_15/a_50_n836# reg__M7
Xreg__M7_9 VSUBS reg__M7_9/a_50_n836# reg__M7_9/w_n144_n898# reg__M7_9/a_n50_n862#
+ reg__M7_16/a_50_n836# reg__M7
Xreg__M7_30 VSUBS reg__M7_30/a_50_n836# reg__M7_9/w_n144_n898# reg__M7_30/a_n50_n862#
+ reg__M7_31/a_50_n836# reg__M7
.ends

.subckt reg__R1 VSUBS a_n35_n1282# a_n35_850#
X0 a_n35_n1282# a_n35_850# VSUBS sky130_fd_pr__res_xhigh_po w=350000u l=8.5e+06u
.ends

.subckt reg__RDUM VSUBS a_n35_n1282# a_n35_850#
X0 a_n35_n1282# a_n35_850# VSUBS sky130_fd_pr__res_xhigh_po w=350000u l=8.5e+06u
.ends

.subckt reg__Rdiv VSUBS m1_949_2758# m1_n145_n183# m1_3059_2758# m1_527_2758#
Xreg__R1_0 VSUBS m1_949_90# m1_949_2758# reg__R1
Xreg__R1_2 VSUBS m1_2215_0# m1_3059_2758# reg__R1
Xreg__R1_1 VSUBS m1_n145_n183# m1_n145_n183# reg__R1
Xreg__R1_3 VSUBS m1_2637_90# m1_3059_2758# reg__R1
Xreg__R1_4 VSUBS m1_2637_90# m1_1371_2758# reg__R1
Xreg__R1_5 VSUBS m1_2215_0# m1_1793_2758# reg__R1
Xreg__R1_6 VSUBS m1_527_0# m1_1793_2758# reg__R1
Xreg__RDUM_0 VSUBS m1_n145_n183# m1_n145_n183# reg__RDUM
Xreg__R1_7 VSUBS m1_949_90# m1_1371_2758# reg__R1
Xreg__R1_8 VSUBS m1_527_0# m1_527_2758# reg__R1
.ends

.subckt regpm__M3 VSUBS a_n100_n162# a_n158_n136# a_100_n136# w_n194_n198#
X0 a_100_n136# a_n100_n162# a_n158_n136# w_n194_n198# sky130_fd_pr__pfet_01v8_lvt ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=1e+06u
.ends

.subckt regpm__DUMP VSUBS a_n100_n162# a_n158_n136# a_100_n136# w_n194_n198#
X0 a_100_n136# a_n100_n162# a_n158_n136# w_n194_n198# sky130_fd_pr__pfet_01v8_lvt ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=1e+06u
.ends

.subckt regpm__M4 VSUBS a_n100_n162# a_n158_n136# a_100_n136# w_n194_n198#
X0 a_100_n136# a_n100_n162# a_n158_n136# w_n194_n198# sky130_fd_pr__pfet_01v8_lvt ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=1e+06u
.ends

.subckt reg__pmirr VSUBS w_60_17# m2_0_1012# m2_0_0#
Xregpm__M3_0 VSUBS m2_0_0# m2_0_0# w_60_17# w_60_17# regpm__M3
Xregpm__M3_1 VSUBS m2_0_0# w_60_17# m2_0_0# w_60_17# regpm__M3
Xregpm__M3_2 VSUBS regpm__M3_2/a_n100_n162# regpm__M3_2/a_n158_n136# regpm__M3_2/a_100_n136#
+ w_60_17# regpm__M3
Xregpm__M3_3 VSUBS m2_0_0# regpm__M3_3/a_n158_n136# m2_0_0# w_60_17# regpm__M3
Xregpm__DUMP_0 VSUBS m2_0_0# m2_0_0# regpm__DUMP_0/a_100_n136# w_60_17# regpm__DUMP
Xregpm__DUMP_1 VSUBS m2_0_0# m2_0_1012# regpm__DUMP_1/a_100_n136# w_60_17# regpm__DUMP
Xregpm__DUMP_2 VSUBS m2_0_0# m2_0_1012# m2_0_1012# w_60_17# regpm__DUMP
Xregpm__DUMP_3 VSUBS m2_0_0# m2_0_0# m2_0_0# w_60_17# regpm__DUMP
Xregpm__M4_0 VSUBS m2_0_0# w_60_17# m2_0_1012# w_60_17# regpm__M4
Xregpm__M4_2 VSUBS m2_0_0# regpm__M4_2/a_n158_n136# m2_0_1012# w_60_17# regpm__M4
Xregpm__M4_1 VSUBS m2_0_0# m2_0_1012# w_60_17# w_60_17# regpm__M4
Xregpm__M4_3 VSUBS regpm__M4_3/a_n100_n162# regpm__M4_3/a_n158_n136# regpm__M4_3/a_100_n136#
+ w_60_17# regpm__M4
.ends

.subckt reg__C1 VSUBS m3_n650_n600# c1_n550_n500#
X0 c1_n550_n500# m3_n650_n600# sky130_fd_pr__cap_mim_m3_1 l=5e+06u w=5e+06u
.ends

.subckt regnm__M5 VSUBS a_n158_n100# a_n100_n126# a_100_n100# w_n184_n126#
X0 a_100_n100# a_n100_n126# a_n158_n100# VSUBS sky130_fd_pr__nfet_01v8_lvt ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=1e+06u
.ends

.subckt regnm__DUM_2 VSUBS a_n158_n131# a_n100_n157# a_100_n131# w_n184_n157#
X0 a_100_n131# a_n100_n157# a_n158_n131# VSUBS sky130_fd_pr__nfet_01v8_lvt ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=1e+06u
.ends

.subckt regnm__M5_gate VSUBS a_n158_n131# a_n100_n157# a_100_n131# w_n184_n157#
X0 a_100_n131# a_n100_n157# a_n158_n131# VSUBS sky130_fd_pr__nfet_01v8_lvt ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=1e+06u
.ends

.subckt regnm__M6 VSUBS a_n158_n100# a_n100_n126# a_100_n100# w_n184_n126#
X0 a_100_n100# a_n100_n126# a_n158_n100# VSUBS sky130_fd_pr__nfet_01v8_lvt ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=1e+06u
.ends

.subckt regnm__M6_gate VSUBS a_n158_n131# a_n100_n157# a_100_n131# w_n184_n157#
X0 a_100_n131# a_n100_n157# a_n158_n131# VSUBS sky130_fd_pr__nfet_01v8_lvt ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=1e+06u
.ends

.subckt regnm__M9 VSUBS w_n226_n269# a_n98_n131# a_n40_n157# a_40_n131#
X0 a_40_n131# a_n40_n157# a_n98_n131# VSUBS sky130_fd_pr__nfet_01v8_lvt ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=400000u
.ends

.subckt regnm__DUM_1 VSUBS a_n158_n100# a_n100_n126# a_100_n100# w_n184_n126#
X0 a_100_n100# a_n100_n126# a_n158_n100# VSUBS sky130_fd_pr__nfet_01v8_lvt ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=1e+06u
.ends

.subckt reg__nmirr VSUBS a_822_233# m1_189_1220# m2_109_42# m2_753_609#
Xregnm__M5_0 VSUBS m2_109_42# a_822_233# m2_753_609# regnm__M6_1/w_n184_n126# regnm__M5
Xregnm__M5_1 VSUBS m2_753_609# a_822_233# m2_109_42# regnm__M6_0/w_n184_n126# regnm__M5
Xregnm__DUM_2_0 VSUBS m2_753_609# a_822_233# m2_753_609# regnm__DUM_2_1/w_n184_n157#
+ regnm__DUM_2
Xregnm__DUM_2_1 VSUBS a_822_233# a_822_233# a_822_233# regnm__DUM_2_1/w_n184_n157#
+ regnm__DUM_2
Xregnm__DUM_2_2 VSUBS a_822_233# a_822_233# regnm__DUM_2_2/a_100_n131# regnm__DUM_2_3/w_n184_n157#
+ regnm__DUM_2
Xregnm__DUM_2_3 VSUBS m2_753_609# a_822_233# m2_753_609# regnm__DUM_2_3/w_n184_n157#
+ regnm__DUM_2
Xregnm__M5_gate_0 VSUBS m2_753_609# a_822_233# m2_109_42# regnm__DUM_2_1/w_n184_n157#
+ regnm__M5_gate
Xregnm__M6_0 VSUBS m2_109_42# a_822_233# a_822_233# regnm__M6_0/w_n184_n126# regnm__M6
Xregnm__M5_gate_1 VSUBS m2_753_609# a_822_233# m2_109_42# regnm__DUM_2_3/w_n184_n157#
+ regnm__M5_gate
Xregnm__M6_1 VSUBS a_822_233# a_822_233# m2_109_42# regnm__M6_1/w_n184_n126# regnm__M6
Xregnm__M6_gate_0 VSUBS m2_109_42# a_822_233# a_822_233# regnm__DUM_2_1/w_n184_n157#
+ regnm__M6_gate
Xregnm__M6_gate_1 VSUBS m2_109_42# a_822_233# a_822_233# regnm__DUM_2_3/w_n184_n157#
+ regnm__M6_gate
Xregnm__M9_0 VSUBS m2_109_42# m2_109_42# m1_189_1220# a_822_233# regnm__M9
Xregnm__DUM_1_0 VSUBS a_822_233# a_822_233# a_822_233# regnm__M6_1/w_n184_n126# regnm__DUM_1
Xregnm__DUM_1_1 VSUBS regnm__DUM_1_1/a_n158_n100# a_822_233# m2_753_609# regnm__M6_0/w_n184_n126#
+ regnm__DUM_1
Xregnm__DUM_1_3 VSUBS a_822_233# a_822_233# a_822_233# regnm__M6_0/w_n184_n126# regnm__DUM_1
Xregnm__DUM_1_2 VSUBS m2_753_609# a_822_233# m2_753_609# regnm__M6_1/w_n184_n126#
+ regnm__DUM_1
.ends

.subckt reginv__MP VSUBS w_n236_n284#
X0 a_40_n64# a_n40_n161# a_n98_n64# w_n236_n284# sky130_fd_pr__pfet_01v8_lvt ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=400000u
.ends

.subckt reginv__MN VSUBS w_n226_n269# a_n98_n131# a_n40_n157# a_40_n131#
X0 a_40_n131# a_n40_n157# a_n98_n131# VSUBS sky130_fd_pr__nfet_01v8_lvt ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=400000u
.ends

.subckt reg__inv_lvt VSUBS m2_0_899# reginv__MP_0/w_n236_n284# m2_0_214# m2_289_297#
+ m1_0_545#
Xreginv__MP_0 VSUBS reginv__MP_0/w_n236_n284# reginv__MP
Xreginv__MN_0 VSUBS m2_0_214# m2_0_214# m1_0_545# m2_289_297# reginv__MN
.ends

.subckt regulator VSUBS m3_0_380# m3_0_3027# m3_0_4161# m3_0_734# m3_0_2714# m3_0_3287#
Xreg__M8_0 VSUBS m3_0_4161# m4_1820_6897# m3_0_3027# m3_0_3027# reg__M8
Xreg__diffpair_0 VSUBS m2_3245_2377# m2_7057_1092# m3_3434_2394# m4_1820_6897# m3_0_734#
+ m3_0_380# reg__diffpair
Xreg__M7_array_0 VSUBS m3_0_3027# m3_0_3287# m3_0_3287# m3_0_3027# m3_0_3287# m3_0_3027#
+ m3_0_3287# m3_0_3287# m3_0_3027# m3_0_3027# m4_1820_6897# m4_1820_6897# m3_0_3027#
+ m4_1820_6897# m4_1820_6897# m3_0_3287# m3_0_3027# m4_1820_6897# m3_0_3027# m4_1820_6897#
+ m3_0_3027# m4_1820_6897# m4_1820_6897# m3_0_3287# m3_0_3027# m4_1820_6897# m3_0_3287#
+ m4_1820_6897# m4_1820_6897# m4_1820_6897# m3_0_3287# m4_1820_6897# m4_1820_6897#
+ m4_1820_6897# m3_0_3287# m3_0_3027# m4_1820_6897# m4_1820_6897# m4_1820_6897# m4_1820_6897#
+ m4_1820_6897# m4_1820_6897# m4_1820_6897# m4_1820_6897# m3_0_3287# m4_1820_6897#
+ m4_1820_6897# m4_1820_6897# m4_1820_6897# m4_1820_6897# m4_1820_6897# m3_0_3287#
+ m3_0_3027# m4_1820_6897# m3_0_3287# m3_0_3287# m3_0_3027# m3_0_3027# m4_1820_6897#
+ m3_0_3287# m4_1820_6897# m3_0_3027# m3_0_3287# m3_0_3027# m3_0_3287# m3_0_3027#
+ reg__M7_array
Xreg__Rdiv_0 VSUBS m3_0_3287# m3_0_380# m3_3434_2394# m3_0_380# reg__Rdiv
Xreg__pmirr_0 VSUBS m3_0_3027# m4_1820_6897# m2_7057_1092# reg__pmirr
Xreg__C1_0 VSUBS m4_1820_6897# m3_0_3287# reg__C1
Xreg__nmirr_0 VSUBS m3_0_2714# m1_1322_4171# m3_0_380# m2_3245_2377# reg__nmirr
Xreg__C1_1 VSUBS m4_1820_6897# m3_0_3287# reg__C1
Xreg__C1_2 VSUBS m4_1820_6897# m3_0_3287# reg__C1
Xreg__C1_3 VSUBS m4_1820_6897# m3_0_3287# reg__C1
Xreg__C1_4 VSUBS m4_1820_6897# m3_0_3287# reg__C1
Xreg__C1_5 VSUBS m4_1820_6897# m3_0_3287# reg__C1
Xreg__C1_6 VSUBS m4_1820_6897# m3_0_3287# reg__C1
Xreg__C1_7 VSUBS m4_1820_6897# m3_0_3287# reg__C1
Xreg__inv_lvt_0 VSUBS m3_0_3027# m3_0_3027# m3_0_380# m1_1322_4171# m3_0_4161# reg__inv_lvt
.ends

.subckt bin__MN4 VSUBS a_n200_n126# a_200_n100# w_n284_n126# a_n258_n100#
X0 a_200_n100# a_n200_n126# a_n258_n100# VSUBS sky130_fd_pr__nfet_01v8_lvt ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=2e+06u
.ends

.subckt bin__DUM_B VSUBS a_n200_n126# a_200_n100# w_n284_n126# a_n258_n100#
X0 a_200_n100# a_n200_n126# a_n258_n100# VSUBS sky130_fd_pr__nfet_01v8_lvt ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=2e+06u
.ends

.subckt bin__MNS4 VSUBS a_n200_n126# a_200_n100# w_n284_n126# a_n258_n100#
X0 a_200_n100# a_n200_n126# a_n258_n100# VSUBS sky130_fd_pr__nfet_01v8_lvt ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=2e+06u
.ends

.subckt bin__MN2 VSUBS a_n200_n126# a_200_n100# w_n284_n126# a_n258_n100#
X0 a_200_n100# a_n200_n126# a_n258_n100# VSUBS sky130_fd_pr__nfet_01v8_lvt ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=2e+06u
.ends

.subckt bin__MNS2 VSUBS a_n200_n126# a_200_n100# w_n284_n126# a_n258_n100#
X0 a_200_n100# a_n200_n126# a_n258_n100# VSUBS sky130_fd_pr__nfet_01v8_lvt ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=2e+06u
.ends

.subckt bin__DUM_A VSUBS a_n258_n131# a_n200_n157# a_200_n131# w_n284_n157#
X0 a_200_n131# a_n200_n157# a_n258_n131# VSUBS sky130_fd_pr__nfet_01v8_lvt ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=2e+06u
.ends

.subckt bin__MN3 VSUBS a_n200_n126# a_200_n100# w_n284_n126# a_n258_n100#
X0 a_200_n100# a_n200_n126# a_n258_n100# VSUBS sky130_fd_pr__nfet_01v8_lvt ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=2e+06u
.ends

.subckt bin__MNS3 VSUBS a_n200_n126# a_200_n100# w_n284_n126# a_n258_n100#
X0 a_200_n100# a_n200_n126# a_n258_n100# VSUBS sky130_fd_pr__nfet_01v8_lvt ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=2e+06u
.ends

.subckt bi__nmirr VSUBS m2_103_0# m3_708_280# m3_250_140# a_777_582#
Xbin__MN4_0 VSUBS a_777_582# m3_250_140# bin__MN4_1/w_n284_n126# bin__MNS4_1/a_200_n100#
+ bin__MN4
Xbin__MN4_1 VSUBS a_777_582# m3_250_140# bin__MN4_1/w_n284_n126# bin__MNS4_0/a_200_n100#
+ bin__MN4
Xbin__MN4_2 VSUBS a_777_582# m3_250_140# bin__MN4_3/w_n284_n126# bin__MNS4_2/a_200_n100#
+ bin__MN4
Xbin__DUM_B_0 VSUBS a_777_582# m3_708_280# bin__MN3_1/w_n284_n126# m3_708_280# bin__DUM_B
Xbin__MNS4_0 VSUBS a_1693_582# bin__MNS4_0/a_200_n100# bin__MN4_1/w_n284_n126# m2_103_0#
+ bin__MNS4
Xbin__MN2_0 VSUBS a_777_582# a_777_582# bin__MN2_1/w_n284_n126# a_1693_582# bin__MN2
Xbin__MN4_3 VSUBS a_777_582# m3_250_140# bin__MN4_3/w_n284_n126# bin__MNS4_3/a_200_n100#
+ bin__MN4
Xbin__DUM_B_1 VSUBS a_777_582# m3_250_140# bin__MN4_1/w_n284_n126# m3_250_140# bin__DUM_B
Xbin__MNS4_1 VSUBS a_1693_582# bin__MNS4_1/a_200_n100# bin__MN4_1/w_n284_n126# m2_103_0#
+ bin__MNS4
Xbin__DUM_B_2 VSUBS a_777_582# m3_250_140# bin__MN4_1/w_n284_n126# m3_250_140# bin__DUM_B
Xbin__MN2_1 VSUBS a_777_582# a_777_582# bin__MN2_1/w_n284_n126# a_1693_582# bin__MN2
Xbin__MN2_2 VSUBS a_777_582# a_777_582# bin__MN2_3/w_n284_n126# a_1693_582# bin__MN2
Xbin__MNS4_2 VSUBS a_1693_582# bin__MNS4_2/a_200_n100# bin__MN4_3/w_n284_n126# m2_103_0#
+ bin__MNS4
Xbin__DUM_B_3 VSUBS a_777_582# m3_708_280# bin__MN3_1/w_n284_n126# m3_708_280# bin__DUM_B
Xbin__MNS4_3 VSUBS a_1693_582# bin__MNS4_3/a_200_n100# bin__MN4_3/w_n284_n126# m2_103_0#
+ bin__MNS4
Xbin__MN2_3 VSUBS a_777_582# a_777_582# bin__MN2_3/w_n284_n126# a_1693_582# bin__MN2
Xbin__MNS2_0 VSUBS a_1693_582# a_1693_582# bin__MN2_1/w_n284_n126# m2_103_0# bin__MNS2
Xbin__DUM_B_4 VSUBS a_777_582# a_777_582# bin__MN2_1/w_n284_n126# a_777_582# bin__DUM_B
Xbin__MNS2_1 VSUBS a_1693_582# a_1693_582# bin__MN2_1/w_n284_n126# m2_103_0# bin__MNS2
Xbin__DUM_B_5 VSUBS a_777_582# m3_708_280# bin__MN3_3/w_n284_n126# m3_708_280# bin__DUM_B
Xbin__MNS2_2 VSUBS a_1693_582# a_1693_582# bin__MN2_3/w_n284_n126# m2_103_0# bin__MNS2
Xbin__DUM_B_6 VSUBS a_777_582# m3_250_140# bin__MN4_3/w_n284_n126# m3_250_140# bin__DUM_B
Xbin__MNS2_3 VSUBS a_1693_582# a_1693_582# bin__MN2_3/w_n284_n126# m2_103_0# bin__MNS2
Xbin__DUM_B_7 VSUBS a_777_582# a_777_582# bin__MN2_1/w_n284_n126# a_777_582# bin__DUM_B
Xbin__DUM_B_8 VSUBS a_777_582# m3_708_280# bin__MN3_3/w_n284_n126# m3_708_280# bin__DUM_B
Xbin__DUM_B_9 VSUBS a_777_582# m3_250_140# bin__MN4_3/w_n284_n126# m3_250_140# bin__DUM_B
Xbin__DUM_A_10 VSUBS m2_103_0# a_1693_582# m2_103_0# bin__DUM_A_7/w_n284_n157# bin__DUM_A
Xbin__DUM_A_11 VSUBS m2_103_0# a_1693_582# m2_103_0# bin__DUM_A_7/w_n284_n157# bin__DUM_A
Xbin__MN3_0 VSUBS a_777_582# m3_708_280# bin__MN3_1/w_n284_n126# bin__MNS3_1/a_200_n100#
+ bin__MN3
Xbin__MN3_1 VSUBS a_777_582# m3_708_280# bin__MN3_1/w_n284_n126# bin__MNS3_0/a_200_n100#
+ bin__MN3
Xbin__MN3_2 VSUBS a_777_582# m3_708_280# bin__MN3_3/w_n284_n126# bin__MNS3_2/a_200_n100#
+ bin__MN3
Xbin__DUM_A_0 VSUBS m2_103_0# a_777_582# m2_103_0# bin__DUM_A_9/w_n284_n157# bin__DUM_A
Xbin__MNS3_0 VSUBS a_1693_582# bin__MNS3_0/a_200_n100# bin__MN3_1/w_n284_n126# m2_103_0#
+ bin__MNS3
Xbin__MN3_3 VSUBS a_777_582# m3_708_280# bin__MN3_3/w_n284_n126# bin__MNS3_3/a_200_n100#
+ bin__MN3
Xbin__DUM_A_1 VSUBS m2_103_0# a_777_582# m2_103_0# bin__DUM_A_9/w_n284_n157# bin__DUM_A
Xbin__MNS3_1 VSUBS a_1693_582# bin__MNS3_1/a_200_n100# bin__MN3_1/w_n284_n126# m2_103_0#
+ bin__MNS3
Xbin__DUM_A_2 VSUBS m2_103_0# a_777_582# m2_103_0# bin__DUM_A_9/w_n284_n157# bin__DUM_A
Xbin__DUM_B_10 VSUBS a_777_582# a_777_582# bin__MN2_3/w_n284_n126# a_777_582# bin__DUM_B
Xbin__MNS3_2 VSUBS a_1693_582# bin__MNS3_2/a_200_n100# bin__MN3_3/w_n284_n126# m2_103_0#
+ bin__MNS3
Xbin__DUM_A_3 VSUBS m2_103_0# a_777_582# m2_103_0# bin__DUM_A_9/w_n284_n157# bin__DUM_A
Xbin__DUM_B_11 VSUBS a_777_582# a_777_582# bin__MN2_3/w_n284_n126# a_777_582# bin__DUM_B
Xbin__MNS3_3 VSUBS a_1693_582# bin__MNS3_3/a_200_n100# bin__MN3_3/w_n284_n126# m2_103_0#
+ bin__MNS3
Xbin__DUM_A_4 VSUBS m2_103_0# a_777_582# m2_103_0# bin__DUM_A_7/w_n284_n157# bin__DUM_A
Xbin__DUM_A_5 VSUBS m2_103_0# a_777_582# m2_103_0# bin__DUM_A_7/w_n284_n157# bin__DUM_A
Xbin__DUM_A_6 VSUBS m2_103_0# a_777_582# m2_103_0# bin__DUM_A_7/w_n284_n157# bin__DUM_A
Xbin__DUM_A_7 VSUBS m2_103_0# a_777_582# m2_103_0# bin__DUM_A_7/w_n284_n157# bin__DUM_A
Xbin__DUM_A_8 VSUBS m2_103_0# a_1693_582# m2_103_0# bin__DUM_A_9/w_n284_n157# bin__DUM_A
Xbin__DUM_A_9 VSUBS m2_103_0# a_1693_582# m2_103_0# bin__DUM_A_9/w_n284_n157# bin__DUM_A
.ends

.subckt bia__M1 VSUBS a_n858_n81# a_800_n81# a_n800_n107# w_n884_n107#
X0 a_800_n81# a_n800_n107# a_n858_n81# VSUBS sky130_fd_pr__nfet_01v8_lvt ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=8e+06u
.ends

.subckt bia__M6 VSUBS a_n458_n81# a_n400_n107# a_400_n81#
X0 a_400_n81# a_n400_n107# a_n458_n81# VSUBS sky130_fd_pr__nfet_01v8_lvt ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=4e+06u
.ends

.subckt bia__M4 VSUBS w_n1094_n148# a_n1058_n86# a_1000_n86# a_n1000_n112#
X0 a_1000_n86# a_n1000_n112# a_n1058_n86# w_n1094_n148# sky130_fd_pr__pfet_01v8_lvt ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=1e+07u
.ends

.subckt bia__M2 VSUBS a_n858_n81# a_800_n81# a_n800_n107# w_n884_n107#
X0 a_800_n81# a_n800_n107# a_n858_n81# VSUBS sky130_fd_pr__nfet_01v8_lvt ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=8e+06u
.ends

.subckt bia__M5 VSUBS a_n458_n81# a_n400_n107# a_400_n81# w_n484_n107#
X0 a_400_n81# a_n400_n107# a_n458_n81# VSUBS sky130_fd_pr__nfet_01v8_lvt ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=4e+06u
.ends

.subckt bia__M5_1 VSUBS a_n458_n81# a_n400_n107# a_400_n81# w_n484_n107#
X0 a_400_n81# a_n400_n107# a_n458_n81# VSUBS sky130_fd_pr__nfet_01v8_lvt ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=4e+06u
.ends

.subckt bia__M3 VSUBS w_n1094_n148# a_n1058_n86# a_1000_n86# a_n1000_n112#
X0 a_1000_n86# a_n1000_n112# a_n1058_n86# w_n1094_n148# sky130_fd_pr__pfet_01v8_lvt ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=1e+07u
.ends

.subckt bi__amplifier VSUBS m3_0_0# m3_0_380# m3_0_3692# m2_567_2404# m3_0_817# m3_0_2232#
Xbia__M1_3 VSUBS m2_727_2721# m2_2167_1048# m3_0_2232# bia__M2_1/w_n884_n107# bia__M1
Xbia__M6_0 VSUBS m3_0_380# m3_0_817# m3_0_817# bia__M6
Xbia__M6_1 VSUBS m3_0_380# m3_0_817# m3_0_817# bia__M6
Xbia__M6_2 VSUBS m3_0_380# m3_0_817# m3_0_817# bia__M6
Xbia__M6_3 VSUBS m3_0_380# m3_0_817# m3_0_817# bia__M6
Xbia__M4_0 VSUBS m3_0_0# m3_0_0# m2_567_2404# m2_727_2721# bia__M4
Xbia__M4_1 VSUBS m3_0_0# m3_0_0# m2_567_2404# m2_727_2721# bia__M4
Xbia__M6_4 VSUBS m3_0_817# m3_0_817# m3_0_380# bia__M6
Xbia__M6_5 VSUBS m3_0_817# m3_0_817# m3_0_380# bia__M6
Xbia__M4_2 VSUBS m3_0_0# m2_567_2404# m3_0_0# m2_727_2721# bia__M4
Xbia__M4_3 VSUBS m3_0_0# m2_567_2404# m3_0_0# m2_727_2721# bia__M4
Xbia__M6_6 VSUBS m3_0_817# m3_0_817# m3_0_380# bia__M6
Xbia__M2_0 VSUBS m2_2167_1048# m2_567_2404# m3_0_3692# bia__M2_0/w_n884_n107# bia__M2
Xbia__M6_7 VSUBS m3_0_817# m3_0_817# m3_0_380# bia__M6
Xbia__M2_1 VSUBS m2_2167_1048# m2_567_2404# m3_0_3692# bia__M2_1/w_n884_n107# bia__M2
Xbia__M2_2 VSUBS m2_567_2404# m2_2167_1048# m3_0_3692# bia__M2_2/w_n884_n107# bia__M2
Xbia__M2_3 VSUBS m2_567_2404# m2_2167_1048# m3_0_3692# bia__M2_3/w_n884_n107# bia__M2
Xbia__M5_0 VSUBS m1_3049_1058# m3_0_817# m3_0_380# bia__M5_0/w_n484_n107# bia__M5
Xbia__M5_1 VSUBS m1_3049_1058# m3_0_817# m3_0_380# bia__M5_1/w_n484_n107# bia__M5
Xbia__M5_1_0 VSUBS m1_3049_1058# m3_0_817# m2_2167_1048# bia__M5_2/w_n484_n107# bia__M5_1
Xbia__M5_2 VSUBS m3_0_380# m3_0_817# m1_3049_1058# bia__M5_2/w_n484_n107# bia__M5
Xbia__M5_1_1 VSUBS m1_3049_1058# m3_0_817# m2_2167_1048# bia__M5_3/w_n484_n107# bia__M5_1
Xbia__M5_3 VSUBS m3_0_380# m3_0_817# m1_3049_1058# bia__M5_3/w_n484_n107# bia__M5
Xbia__M3_0 VSUBS m3_0_0# m3_0_0# m2_727_2721# m2_727_2721# bia__M3
Xbia__M5_1_2 VSUBS m2_2167_1048# m3_0_817# m1_3049_1058# bia__M5_0/w_n484_n107# bia__M5_1
Xbia__M3_1 VSUBS m3_0_0# m3_0_0# m2_727_2721# m2_727_2721# bia__M3
Xbia__M5_1_3 VSUBS m2_2167_1048# m3_0_817# m1_3049_1058# bia__M5_1/w_n484_n107# bia__M5_1
Xbia__M3_2 VSUBS m3_0_0# m2_727_2721# m3_0_0# m2_727_2721# bia__M3
Xbia__M3_3 VSUBS m3_0_0# m2_727_2721# m3_0_0# m2_727_2721# bia__M3
Xbia__M1_0 VSUBS m2_2167_1048# m2_727_2721# m3_0_2232# bia__M2_2/w_n884_n107# bia__M1
Xbia__M1_1 VSUBS m2_2167_1048# m2_727_2721# m3_0_2232# bia__M2_3/w_n884_n107# bia__M1
Xbia__M1_2 VSUBS m2_727_2721# m2_2167_1048# m3_0_2232# bia__M2_0/w_n884_n107# bia__M1
.ends

.subckt bi__cunit VSUBS m3_n650_n600# c1_n550_n500#
X0 c1_n550_n500# m3_n650_n600# sky130_fd_pr__cap_mim_m3_1 l=5e+06u w=5e+06u
.ends

.subckt bi__cfb VSUBS m4_12_4# m4_549_1160# m4_12_2738#
Xbi__cunit_0 VSUBS m4_12_2738# m4_549_1160# bi__cunit
Xbi__cunit_1 VSUBS m4_12_2738# m4_549_1160# bi__cunit
Xbi__cunit_2 VSUBS m4_12_4# m4_549_1160# bi__cunit
Xbi__cunit_4 VSUBS m4_12_2738# m4_549_1160# bi__cunit
Xbi__cunit_3 VSUBS m4_12_4# m4_549_1160# bi__cunit
Xbi__cunit_5 VSUBS m4_12_2738# m4_549_1160# bi__cunit
Xbi__cunit_6 VSUBS m4_12_4# m4_549_1160# bi__cunit
Xbi__cunit_7 VSUBS m4_12_4# m4_549_1160# bi__cunit
.ends

.subckt bir__unit VSUBS a_n69_n3012# a_n69_2580#
X0 a_n69_n3012# a_n69_2580# VSUBS sky130_fd_pr__res_xhigh_po w=690000u l=2.58e+07u
.ends

.subckt bi__rladder bir__unit_15/a_n69_n3012# VSUBS m1_46_5554# m1_46_3866# bir__unit_1/a_n69_2580#
+ bir__unit_0/a_n69_2580# m1_46_4710# bir__unit_0/a_n69_n3012# m1_46_2178# m1_46_490#
+ bir__unit_1/a_n69_n3012# m1_46_3022# m1_46_1334# bir__unit_2/a_n69_n3012#
Xbir__unit_10 VSUBS m1_46_2178# m1_5637_2600# bir__unit
Xbir__unit_12 VSUBS m1_46_1334# m1_5637_1756# bir__unit
Xbir__unit_11 VSUBS m1_46_2178# m1_5637_1756# bir__unit
Xbir__unit_13 VSUBS m1_46_1334# m1_5637_912# bir__unit
Xbir__unit_14 VSUBS m1_46_490# m1_5637_912# bir__unit
Xbir__unit_0 VSUBS bir__unit_0/a_n69_n3012# bir__unit_0/a_n69_2580# bir__unit
Xbir__unit_15 VSUBS bir__unit_15/a_n69_n3012# m1_5637_68# bir__unit
Xbir__unit_1 VSUBS bir__unit_1/a_n69_n3012# bir__unit_1/a_n69_2580# bir__unit
Xbir__unit_16 VSUBS m1_46_490# m1_5637_68# bir__unit
Xbir__unit_2 VSUBS bir__unit_2/a_n69_n3012# m1_5637_5976# bir__unit
Xbir__unit_17 VSUBS m1_46_3022# m1_5637_2600# bir__unit
Xbir__unit_4 VSUBS m1_46_5554# m1_5637_5132# bir__unit
Xbir__unit_3 VSUBS m1_46_5554# m1_5637_5976# bir__unit
Xbir__unit_5 VSUBS m1_46_4710# m1_5637_5132# bir__unit
Xbir__unit_6 VSUBS m1_46_4710# m1_5637_4288# bir__unit
Xbir__unit_7 VSUBS m1_46_3866# m1_5637_4288# bir__unit
Xbir__unit_8 VSUBS m1_46_3866# m1_5637_3444# bir__unit
Xbir__unit_9 VSUBS m1_46_3022# m1_5637_3444# bir__unit
.ends

.subckt bip__DUM1 VSUBS a_n200_n76# a_200_n50# w_n294_n112# a_n258_n50#
X0 a_200_n50# a_n200_n76# a_n258_n50# w_n294_n112# sky130_fd_pr__pfet_01v8_lvt ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=2e+06u
.ends

.subckt bip__MP4 VSUBS a_n200_n76# a_200_n50# w_n294_n112# a_n258_n50#
X0 a_200_n50# a_n200_n76# a_n258_n50# w_n294_n112# sky130_fd_pr__pfet_01v8_lvt ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=2e+06u
.ends

.subckt bip__MPS2 VSUBS a_n200_n76# a_200_n50# w_n294_n112# a_n258_n50#
X0 a_200_n50# a_n200_n76# a_n258_n50# w_n294_n112# sky130_fd_pr__pfet_01v8_lvt ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=2e+06u
.ends

.subckt bip__MP2 VSUBS a_n200_n76# a_200_n50# w_n294_n112# a_n258_n50#
X0 a_200_n50# a_n200_n76# a_n258_n50# w_n294_n112# sky130_fd_pr__pfet_01v8_lvt ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=2e+06u
.ends

.subckt bip__DUM2 VSUBS a_200_n86# w_n294_n148# a_n200_n112# a_n258_n86#
X0 a_200_n86# a_n200_n112# a_n258_n86# w_n294_n148# sky130_fd_pr__pfet_01v8_lvt ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=2e+06u
.ends

.subckt bip__M1 VSUBS a_n200_n76# a_200_n50# w_n294_n112# a_n258_n50#
X0 a_200_n50# a_n200_n76# a_n258_n50# w_n294_n112# sky130_fd_pr__pfet_01v8_lvt ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=2e+06u
.ends

.subckt bip__MPS5 VSUBS a_n200_n76# a_200_n50# w_n294_n112# a_n258_n50#
X0 a_200_n50# a_n200_n76# a_n258_n50# w_n294_n112# sky130_fd_pr__pfet_01v8_lvt ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=2e+06u
.ends

.subckt bip__MP5 VSUBS a_n200_n76# a_200_n50# w_n294_n112# a_n258_n50#
X0 a_200_n50# a_n200_n76# a_n258_n50# w_n294_n112# sky130_fd_pr__pfet_01v8_lvt ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=2e+06u
.ends

.subckt bip__MPS3 VSUBS a_n200_n76# a_200_n50# w_n294_n112# a_n258_n50#
X0 a_200_n50# a_n200_n76# a_n258_n50# w_n294_n112# sky130_fd_pr__pfet_01v8_lvt ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=2e+06u
.ends

.subckt bip__MP3 VSUBS a_n200_n76# a_200_n50# w_n294_n112# a_n258_n50#
X0 a_200_n50# a_n200_n76# a_n258_n50# w_n294_n112# sky130_fd_pr__pfet_01v8_lvt ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=2e+06u
.ends

.subckt bip__MPS6 VSUBS a_n200_n76# a_200_n50# w_n294_n112# a_n258_n50#
X0 a_200_n50# a_n200_n76# a_n258_n50# w_n294_n112# sky130_fd_pr__pfet_01v8_lvt ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=2e+06u
.ends

.subckt bip__MP6 VSUBS a_n200_n76# a_200_n50# w_n294_n112# a_n258_n50#
X0 a_200_n50# a_n200_n76# a_n258_n50# w_n294_n112# sky130_fd_pr__pfet_01v8_lvt ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=2e+06u
.ends

.subckt bip__MPS4 VSUBS a_n200_n76# a_200_n50# w_n294_n112# a_n258_n50#
X0 a_200_n50# a_n200_n76# a_n258_n50# w_n294_n112# sky130_fd_pr__pfet_01v8_lvt ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=2e+06u
.ends

.subckt bi__pmirr VSUBS w_355_349# m3_0_1395# m3_2548_0# m3_2268_1695# m3_2268_0#
+ m3_2408_0# m3_2408_1919# m3_1905_0#
Xbip__DUM1_8 VSUBS m3_0_1395# w_355_349# w_355_349# w_355_349# bip__DUM1
Xbip__MP4_0 VSUBS m3_0_1395# w_355_349# w_355_349# m1_3242_829# bip__MP4
Xbip__DUM1_9 VSUBS m3_0_1395# w_355_349# w_355_349# w_355_349# bip__DUM1
Xbip__MPS2_0 VSUBS m3_0_1395# m1_3242_1053# w_355_349# m3_2268_0# bip__MPS2
Xbip__MP4_1 VSUBS m3_0_1395# m1_1478_829# w_355_349# w_355_349# bip__MP4
Xbip__MPS2_1 VSUBS m3_0_1395# m3_2268_0# w_355_349# m1_1478_1053# bip__MPS2
Xbip__MP2_0 VSUBS m3_0_1395# w_355_349# w_355_349# m1_3242_1053# bip__MP2
Xbip__MP2_1 VSUBS m3_0_1395# m1_1478_1053# w_355_349# w_355_349# bip__MP2
Xbip__DUM2_0 VSUBS w_355_349# w_355_349# m3_0_1395# w_355_349# bip__DUM2
Xbip__DUM2_1 VSUBS w_355_349# w_355_349# m3_0_1395# w_355_349# bip__DUM2
Xbip__DUM2_2 VSUBS w_355_349# w_355_349# m3_0_1395# w_355_349# bip__DUM2
Xbip__DUM2_3 VSUBS w_355_349# w_355_349# m3_0_1395# w_355_349# bip__DUM2
Xbip__DUM2_4 VSUBS w_355_349# w_355_349# m3_0_1395# w_355_349# bip__DUM2
Xbip__M1_0 VSUBS m3_0_1395# w_355_349# w_355_349# m3_1905_0# bip__M1
Xbip__DUM2_5 VSUBS w_355_349# w_355_349# m3_0_1395# w_355_349# bip__DUM2
Xbip__M1_1 VSUBS m3_0_1395# m3_1905_0# w_355_349# w_355_349# bip__M1
Xbip__DUM2_6 VSUBS w_355_349# w_355_349# m3_0_1395# w_355_349# bip__DUM2
Xbip__MPS5_0 VSUBS m3_0_1395# m3_2268_1695# w_355_349# m1_1478_1725# bip__MPS5
Xbip__M1_2 VSUBS m3_0_1395# w_355_349# w_355_349# m3_1905_0# bip__M1
Xbip__MPS5_1 VSUBS m3_0_1395# m1_3242_1725# w_355_349# m3_2268_1695# bip__MPS5
Xbip__DUM2_7 VSUBS w_355_349# w_355_349# m3_0_1395# w_355_349# bip__DUM2
Xbip__M1_3 VSUBS m3_0_1395# w_355_349# w_355_349# m3_1905_0# bip__M1
Xbip__DUM2_8 VSUBS w_355_349# w_355_349# m3_0_1395# w_355_349# bip__DUM2
Xbip__MP5_0 VSUBS m3_0_1395# m1_1478_1725# w_355_349# w_355_349# bip__MP5
Xbip__M1_4 VSUBS m3_0_1395# w_355_349# w_355_349# m3_1905_0# bip__M1
Xbip__DUM2_9 VSUBS w_355_349# w_355_349# m3_0_1395# w_355_349# bip__DUM2
Xbip__MPS3_0 VSUBS m3_0_1395# m3_2548_0# w_355_349# m1_1478_1501# bip__MPS3
Xbip__MP5_1 VSUBS m3_0_1395# w_355_349# w_355_349# m1_3242_1725# bip__MP5
Xbip__M1_5 VSUBS m3_0_1395# w_355_349# w_355_349# m3_1905_0# bip__M1
Xbip__MPS3_1 VSUBS m3_0_1395# m1_3242_1501# w_355_349# m3_2548_0# bip__MPS3
Xbip__M1_6 VSUBS m3_0_1395# w_355_349# w_355_349# m3_1905_0# bip__M1
Xbip__MPS3_2 VSUBS m3_0_1395# m1_3242_1277# w_355_349# m3_2548_0# bip__MPS3
Xbip__M1_7 VSUBS m3_0_1395# w_355_349# w_355_349# m3_1905_0# bip__M1
Xbip__MP3_0 VSUBS m3_0_1395# m1_1478_1501# w_355_349# w_355_349# bip__MP3
Xbip__MPS3_3 VSUBS m3_0_1395# m3_2548_0# w_355_349# m1_1478_1277# bip__MPS3
Xbip__MP3_1 VSUBS m3_0_1395# w_355_349# w_355_349# m1_3242_1501# bip__MP3
Xbip__MP3_2 VSUBS m3_0_1395# w_355_349# w_355_349# m1_3242_1277# bip__MP3
Xbip__MP3_3 VSUBS m3_0_1395# m1_1478_1277# w_355_349# w_355_349# bip__MP3
Xbip__DUM2_10 VSUBS w_355_349# w_355_349# m3_0_1395# w_355_349# bip__DUM2
Xbip__DUM2_11 VSUBS w_355_349# w_355_349# m3_0_1395# w_355_349# bip__DUM2
Xbip__DUM2_12 VSUBS w_355_349# w_355_349# m3_0_1395# w_355_349# bip__DUM2
Xbip__DUM2_13 VSUBS w_355_349# w_355_349# m3_0_1395# w_355_349# bip__DUM2
Xbip__DUM1_0 VSUBS m3_0_1395# w_355_349# w_355_349# w_355_349# bip__DUM1
Xbip__DUM1_1 VSUBS m3_0_1395# w_355_349# w_355_349# w_355_349# bip__DUM1
Xbip__DUM1_2 VSUBS m3_0_1395# w_355_349# w_355_349# w_355_349# bip__DUM1
Xbip__MPS6_0 VSUBS m3_0_1395# m3_2408_1919# w_355_349# m1_1478_1949# bip__MPS6
Xbip__DUM1_3 VSUBS m3_0_1395# w_355_349# w_355_349# w_355_349# bip__DUM1
Xbip__MPS6_1 VSUBS m3_0_1395# m1_3242_1949# w_355_349# m3_2408_1919# bip__MPS6
Xbip__DUM1_4 VSUBS m3_0_1395# w_355_349# w_355_349# w_355_349# bip__DUM1
Xbip__DUM1_5 VSUBS m3_0_1395# w_355_349# w_355_349# w_355_349# bip__DUM1
Xbip__MP6_0 VSUBS m3_0_1395# m1_1478_1949# w_355_349# w_355_349# bip__MP6
Xbip__MPS4_0 VSUBS m3_0_1395# m1_3242_829# w_355_349# m3_2408_0# bip__MPS4
Xbip__DUM1_6 VSUBS m3_0_1395# w_355_349# w_355_349# w_355_349# bip__DUM1
Xbip__MP6_1 VSUBS m3_0_1395# w_355_349# w_355_349# m1_3242_1949# bip__MP6
Xbip__MPS4_1 VSUBS m3_0_1395# m3_2408_0# w_355_349# m1_1478_829# bip__MPS4
Xbip__DUM1_7 VSUBS m3_0_1395# w_355_349# w_355_349# w_355_349# bip__DUM1
.ends

.subckt bias VSUBS m2_11790_0# m2_13330_0# m3_0_0# m2_12630_0# m2_11930_0# m2_13050_0#
+ m3_0_380# m2_12350_0# m3_0_3692# m2_11650_0# m2_12770_0# m3_0_817# m2_12070_0# m2_13190_0#
+ m2_12910_0# m2_12490_0# m2_12210_0#
Xbi__nmirr_0 VSUBS m3_0_380# m2_11790_0# m2_11650_0# m3_9769_5086# bi__nmirr
Xbi__amplifier_0 VSUBS m3_0_0# m3_0_380# m3_0_3692# m4_6166_7354# m3_0_817# m4_253_2433#
+ bi__amplifier
Xbi__cfb_0 VSUBS m4_253_2433# m4_6166_7354# m4_253_2433# bi__cfb
Xbi__rladder_0 m3_0_380# VSUBS m2_12490_0# m2_12770_0# m3_0_380# m3_0_380# m2_12630_0#
+ m3_0_380# m2_13050_0# m2_13330_0# m3_0_380# m2_12910_0# m2_13190_0# m4_253_2433#
+ bi__rladder
Xbi__pmirr_0 VSUBS m3_0_0# m4_6166_7354# m2_12070_0# m2_12350_0# m3_9769_5086# m2_11930_0#
+ m2_12210_0# m4_253_2433# bi__pmirr
.ends

.subckt ropm__M2 VSUBS a_n500_n162# a_n558_n136# a_500_n136# w_n594_n198#
X0 a_500_n136# a_n500_n162# a_n558_n136# w_n594_n198# sky130_fd_pr__pfet_01v8 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=5e+06u
.ends

.subckt ropm__M1 VSUBS a_n500_n162# a_n558_n136# a_500_n136# w_n594_n198#
X0 a_500_n136# a_n500_n162# a_n558_n136# w_n594_n198# sky130_fd_pr__pfet_01v8 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=5e+06u
.ends

.subckt ro__pmirr VSUBS w_0_42# m2_278_149# m2_0_2436#
Xropm__M2_9 VSUBS m2_0_2436# m2_278_149# w_0_42# w_0_42# ropm__M2
Xropm__M1_0 VSUBS m2_0_2436# w_0_42# m2_0_2436# w_0_42# ropm__M1
Xropm__M1_1 VSUBS m2_0_2436# m2_0_2436# w_0_42# w_0_42# ropm__M1
Xropm__M1_2 VSUBS m2_0_2436# m2_0_2436# w_0_42# w_0_42# ropm__M1
Xropm__M1_3 VSUBS m2_0_2436# w_0_42# m2_0_2436# w_0_42# ropm__M1
Xropm__M2_0 VSUBS m2_0_2436# w_0_42# m2_278_149# w_0_42# ropm__M2
Xropm__M2_1 VSUBS m2_0_2436# w_0_42# m2_278_149# w_0_42# ropm__M2
Xropm__M2_10 VSUBS m2_0_2436# w_0_42# m2_278_149# w_0_42# ropm__M2
Xropm__M2_2 VSUBS m2_0_2436# m2_278_149# w_0_42# w_0_42# ropm__M2
Xropm__M2_11 VSUBS m2_0_2436# w_0_42# m2_278_149# w_0_42# ropm__M2
Xropm__M2_3 VSUBS m2_0_2436# m2_278_149# w_0_42# w_0_42# ropm__M2
Xropm__M2_12 VSUBS m2_0_2436# m2_278_149# w_0_42# w_0_42# ropm__M2
Xropm__M2_4 VSUBS m2_0_2436# m2_278_149# w_0_42# w_0_42# ropm__M2
Xropm__M2_13 VSUBS m2_0_2436# m2_278_149# w_0_42# w_0_42# ropm__M2
Xropm__M2_5 VSUBS m2_0_2436# m2_278_149# w_0_42# w_0_42# ropm__M2
Xropm__M2_14 VSUBS m2_0_2436# w_0_42# m2_278_149# w_0_42# ropm__M2
Xropm__M2_6 VSUBS m2_0_2436# w_0_42# m2_278_149# w_0_42# ropm__M2
Xropm__M2_15 VSUBS m2_0_2436# m2_278_149# w_0_42# w_0_42# ropm__M2
Xropm__M2_7 VSUBS m2_0_2436# w_0_42# m2_278_149# w_0_42# ropm__M2
Xropm__M2_8 VSUBS m2_0_2436# w_0_42# m2_278_149# w_0_42# ropm__M2
.ends

.subckt roc__inv VSUBS a_102_247# a_106_345# w_0_309# a_188_95# a_106_95#
X0 a_188_95# a_102_247# a_106_95# VSUBS sky130_fd_pr__nfet_01v8 ad=1.69e+11p pd=1.82e+06u as=1.69e+11p ps=1.82e+06u w=650000u l=150000u
X1 a_188_95# a_102_247# a_106_345# w_0_309# sky130_fd_pr__pfet_01v8_hvt ad=2.6e+11p pd=2.52e+06u as=2.6e+11p ps=2.52e+06u w=1e+06u l=150000u
.ends

.subckt roc__nand VSUBS w_0_309# a_69_95# a_205_69# a_59_247# a_151_345# a_69_345#
X0 a_151_345# a_205_69# a_151_95# VSUBS sky130_fd_pr__nfet_01v8 ad=1.69e+11p pd=1.82e+06u as=1.755e+11p ps=1.84e+06u w=650000u l=150000u
X1 a_151_95# a_59_247# a_69_95# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.69e+11p ps=1.82e+06u w=650000u l=150000u
X2 a_69_345# a_205_69# a_151_345# w_0_309# sky130_fd_pr__pfet_01v8_hvt ad=5.2e+11p pd=5.04e+06u as=2.7e+11p ps=2.54e+06u w=1e+06u l=150000u
X3 a_151_345# a_59_247# a_69_345# w_0_309# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
.ends

.subckt roc__cap VSUBS m3_n500_n450# c1_n400_n350#
X0 c1_n400_n350# m3_n500_n450# sky130_fd_pr__cap_mim_m3_1 l=3.5e+06u w=3.5e+06u
.ends

.subckt ro__rosc_core VSUBS roc__cap_6/m3_n500_n450# roc__cap_3/m3_n500_n450# m1_2397_2642#
+ roc__cap_0/m3_n500_n450# roc__cap_5/m3_n500_n450# m2_183_2327# li_817_2271# roc__cap_2/m3_n500_n450#
+ m1_n524_2002# roc__cap_4/m3_n500_n450# roc__cap_1/m3_n500_n450#
Xroc__inv_0 VSUBS m4_2272_1419# m1_2397_2642# m1_2397_2642# m2_183_2327# m1_n524_2002#
+ roc__inv
Xroc__inv_1 VSUBS m4_1996_1259# m1_2397_2642# m1_2397_2642# m4_2272_1419# m1_n524_2002#
+ roc__inv
Xroc__inv_2 VSUBS m4_1720_1099# m1_2397_2642# m1_2397_2642# m4_1996_1259# m1_n524_2002#
+ roc__inv
Xroc__inv_4 VSUBS m4_1168_794# m1_2397_2642# m1_2397_2642# m4_1444_939# m1_n524_2002#
+ roc__inv
Xroc__inv_3 VSUBS m4_1444_939# m1_2397_2642# m1_2397_2642# m4_1720_1099# m1_n524_2002#
+ roc__inv
Xroc__inv_5 VSUBS m4_409_576# m1_2397_2642# m1_2397_2642# m4_1168_794# m1_n524_2002#
+ roc__inv
Xroc__nand_0 VSUBS m1_2397_2642# m1_n524_2002# li_817_2271# m2_183_2327# m4_409_576#
+ m1_2397_2642# roc__nand
Xroc__cap_0 VSUBS roc__cap_0/m3_n500_n450# m4_409_576# roc__cap
Xroc__cap_1 VSUBS roc__cap_1/m3_n500_n450# m4_1168_794# roc__cap
Xroc__cap_2 VSUBS roc__cap_2/m3_n500_n450# m4_1444_939# roc__cap
Xroc__cap_3 VSUBS roc__cap_3/m3_n500_n450# m4_1720_1099# roc__cap
Xroc__cap_4 VSUBS roc__cap_4/m3_n500_n450# m4_1996_1259# roc__cap
Xroc__cap_6 VSUBS roc__cap_6/m3_n500_n450# m2_183_2327# roc__cap
Xroc__cap_5 VSUBS roc__cap_5/m3_n500_n450# m4_2272_1419# roc__cap
.ends

.subckt roi__inv_1 VSUBS a_102_247# a_106_345# w_0_309# a_188_95# a_106_95#
X0 a_188_95# a_102_247# a_106_95# VSUBS sky130_fd_pr__nfet_01v8 ad=1.69e+11p pd=1.82e+06u as=1.69e+11p ps=1.82e+06u w=650000u l=150000u
X1 a_188_95# a_102_247# a_106_345# w_0_309# sky130_fd_pr__pfet_01v8_hvt ad=2.6e+11p pd=2.52e+06u as=2.6e+11p ps=2.52e+06u w=1e+06u l=150000u
.ends

.subckt roi__dfrbp_1 VSUBS a_147_411# a_147_95# a_60_247# w_0_309# a_1748_345# a_369_308#
+ a_885_69#
X0 a_677_95# a_231_95# a_581_95# VSUBS sky130_fd_pr__nfet_01v8 ad=2.802e+11p pd=2.2e+06u as=1.188e+11p ps=1.38e+06u w=360000u l=150000u
X1 a_1321_69# a_1146_95# a_1500_95# VSUBS sky130_fd_pr__nfet_01v8 ad=1.092e+11p pd=1.36e+06u as=1.281e+11p ps=1.45e+06u w=420000u l=150000u
X2 a_689_461# a_65_95# a_581_95# w_0_309# sky130_fd_pr__pfet_01v8_hvt ad=3.402e+11p pd=3.3e+06u as=1.449e+11p ps=1.53e+06u w=420000u l=150000u
X3 a_843_95# a_799_337# a_677_95# VSUBS sky130_fd_pr__nfet_01v8 ad=8.82e+10p pd=1.26e+06u as=0p ps=0u w=420000u l=150000u
X4 a_581_95# a_231_95# a_486_95# w_0_309# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=1.302e+11p ps=1.46e+06u w=420000u l=150000u
X5 a_147_95# a_885_69# a_843_95# VSUBS sky130_fd_pr__nfet_01v8 ad=1.2225e+12p pd=1.139e+07u as=0p ps=0u w=420000u l=150000u
X6 a_147_95# a_60_247# a_65_95# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.092e+11p ps=1.36e+06u w=420000u l=150000u
X7 a_486_95# a_369_308# a_147_411# w_0_309# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=1.5393e+12p ps=1.452e+07u w=420000u l=150000u
X8 a_147_411# a_60_247# a_65_95# w_0_309# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=1.664e+11p ps=1.8e+06u w=640000u l=150000u
X9 a_147_411# a_799_337# a_689_461# w_0_309# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X10 a_1748_345# a_1321_69# a_147_95# VSUBS sky130_fd_pr__nfet_01v8 ad=1.69e+11p pd=1.82e+06u as=0p ps=0u w=650000u l=150000u
X11 a_147_95# a_1321_69# a_1255_95# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.338e+11p ps=1.5e+06u w=420000u l=150000u
X12 a_689_461# a_885_69# a_147_411# w_0_309# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X13 a_1500_95# a_885_69# a_147_95# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X14 a_147_95# a_1321_69# a_1885_95# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.092e+11p ps=1.36e+06u w=420000u l=150000u
X15 a_231_95# a_65_95# a_147_411# w_0_309# sky130_fd_pr__pfet_01v8_hvt ad=1.664e+11p pd=1.8e+06u as=0p ps=0u w=640000u l=150000u
X16 a_147_411# a_1146_95# a_1321_69# w_0_309# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=1.134e+11p ps=1.38e+06u w=420000u l=150000u
X17 a_2064_95# a_1885_95# a_147_95# VSUBS sky130_fd_pr__nfet_01v8 ad=1.69e+11p pd=1.82e+06u as=0p ps=0u w=650000u l=150000u
X18 a_147_411# a_1321_69# a_1885_95# w_0_309# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=1.664e+11p ps=1.8e+06u w=640000u l=150000u
X19 a_1255_95# a_65_95# a_1146_95# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.422e+11p ps=1.51e+06u w=360000u l=150000u
X20 a_1308_461# a_231_95# a_1146_95# w_0_309# sky130_fd_pr__pfet_01v8_hvt ad=1.134e+11p pd=1.38e+06u as=1.176e+11p ps=1.4e+06u w=420000u l=150000u
X21 a_1146_95# a_65_95# a_799_337# w_0_309# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.583e+11p ps=2.37e+06u w=420000u l=150000u
X22 a_1321_69# a_885_69# a_147_411# w_0_309# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X23 a_2064_95# a_1885_95# a_147_411# w_0_309# sky130_fd_pr__pfet_01v8_hvt ad=2.6e+11p pd=2.52e+06u as=0p ps=0u w=1e+06u l=150000u
X24 a_486_95# a_369_308# a_147_95# VSUBS sky130_fd_pr__nfet_01v8 ad=1.32e+11p pd=1.49e+06u as=0p ps=0u w=420000u l=150000u
X25 a_147_411# a_1321_69# a_1308_461# w_0_309# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X26 a_799_337# a_581_95# a_147_411# w_0_309# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=840000u l=150000u
X27 a_1748_345# a_1321_69# a_147_411# w_0_309# sky130_fd_pr__pfet_01v8_hvt ad=2.8e+11p pd=2.56e+06u as=0p ps=0u w=1e+06u l=150000u
X28 a_1146_95# a_231_95# a_799_337# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.998e+11p ps=1.97e+06u w=360000u l=150000u
X29 a_231_95# a_65_95# a_147_95# VSUBS sky130_fd_pr__nfet_01v8 ad=1.092e+11p pd=1.36e+06u as=0p ps=0u w=420000u l=150000u
X30 a_799_337# a_581_95# a_147_95# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=640000u l=150000u
X31 a_581_95# a_65_95# a_486_95# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=360000u l=150000u
.ends

.subckt ro__interface roi__inv_1_1/w_0_309# VSUBS li_110_269# roi__inv_1_1/a_106_345#
+ m2_1772_374# li_2058_345# roi__inv_1_1/a_106_95#
Xroi__inv_1_0 VSUBS li_110_269# roi__inv_1_1/a_106_345# roi__inv_1_1/w_0_309# li_198_154#
+ roi__inv_1_1/a_106_95# roi__inv_1
Xroi__inv_1_1 VSUBS li_2058_345# roi__inv_1_1/a_106_345# roi__inv_1_1/w_0_309# m2_463_444#
+ roi__inv_1_1/a_106_95# roi__inv_1
Xroi__dfrbp_1_0 VSUBS roi__inv_1_1/a_106_345# roi__inv_1_1/a_106_95# li_198_154# roi__inv_1_1/w_0_309#
+ li_2058_345# m2_463_444# m2_1772_374# roi__dfrbp_1
.ends

.subckt rosc VSUBS m3_9764_0# m3_7446_3993# m3_0_380# m1_8391_3020# m3_0_0# m3_0_3054#
+ m3_0_7139# m3_9291_380#
Xro__pmirr_0 VSUBS m3_0_0# m1_3559_3302# m3_0_7139# ro__pmirr
Xro__rosc_core_0 VSUBS m3_0_380# m3_0_380# m1_3559_3302# m3_0_380# m3_0_380# m1_4204_3020#
+ m3_0_3054# m3_0_380# m3_0_380# m3_0_380# m3_0_380# ro__rosc_core
Xro__interface_0 m3_9764_0# VSUBS m1_4204_3020# m3_9764_0# m3_7446_3993# m1_8391_3020#
+ m3_9291_380# ro__interface
.ends

.subckt pg__MPINV VSUBS a_n40_n161# a_n98_n64# w_n134_n164# a_40_n64#
X0 a_40_n64# a_n40_n161# a_n98_n64# w_n134_n164# sky130_fd_pr__pfet_01v8_lvt ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=400000u
.ends

.subckt pg__MSP VSUBS a_n50_n161# a_50_n64# w_n144_n164# a_n108_n64#
X0 a_50_n64# a_n50_n161# a_n108_n64# w_n144_n164# sky130_fd_pr__pfet_01v8 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
.ends

.subckt pg__MNINV VSUBS a_n98_n131# a_n40_n157# a_40_n131#
X0 a_40_n131# a_n40_n157# a_n98_n131# VSUBS sky130_fd_pr__nfet_01v8_lvt ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=400000u
.ends

.subckt pg__MSN VSUBS a_n108_n131# a_n50_n157# a_50_n131#
X0 a_50_n131# a_n50_n157# a_n108_n131# VSUBS sky130_fd_pr__nfet_01v8 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
.ends

.subckt passgate VSUBS m2_1694_0# m1_0_923# m1_103_270# w_73_1005# m2_1010_0#
Xpg__MPINV_0 VSUBS m1_0_923# w_73_1005# w_73_1005# m1_444_471# pg__MPINV
Xpg__MPINV_1 VSUBS m1_444_471# w_73_1005# w_73_1005# m2_844_991# pg__MPINV
Xpg__MSP_0 VSUBS m2_514_847# m2_1694_0# w_73_1005# m2_1010_0# pg__MSP
Xpg__MNINV_0 VSUBS m1_103_270# m1_444_471# m2_844_991# pg__MNINV
Xpg__MNINV_1 pg__MNINV_1/VSUBS pg__MNINV_1/a_n98_n131# pg__MNINV_1/a_n40_n157# pg__MNINV_1/a_40_n131#
+ pg__MNINV
Xpg__MSN_0 VSUBS m2_1010_0# m2_844_991# m2_1694_0# pg__MSN
.ends

.subckt cs__decap_4 VSUBS a_59_273# w_0_309# a_65_371#
X0 a_65_371# a_59_273# a_65_371# w_0_309# sky130_fd_pr__pfet_01v8_hvt ad=4.524e+11p pd=4.52e+06u as=0p ps=0u w=870000u l=1.05e+06u
X1 a_59_273# a_65_371# a_59_273# VSUBS sky130_fd_pr__nfet_01v8 ad=2.86e+11p pd=3.24e+06u as=0p ps=0u w=550000u l=1.05e+06u
.ends

.subckt cs__mux2 VSUBS a_147_95# a_65_345# a_671_69# w_0_309# a_487_233# a_65_95#
+ a_391_69#
X0 a_295_247# a_671_69# a_65_95# VSUBS sky130_fd_pr__nfet_01v8 ad=1.134e+11p pd=1.38e+06u as=4.764e+11p ps=5.15e+06u w=420000u l=150000u
X1 a_147_95# a_117_69# a_65_95# VSUBS sky130_fd_pr__nfet_01v8 ad=1.755e+11p pd=1.84e+06u as=0p ps=0u w=650000u l=150000u
X2 a_65_95# a_671_69# a_616_95# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.155e+11p ps=1.39e+06u w=420000u l=150000u
X3 a_117_69# a_487_233# a_344_417# w_0_309# sky130_fd_pr__pfet_01v8_hvt ad=2.624e+11p pd=2.1e+06u as=4.576e+11p ps=2.71e+06u w=640000u l=150000u
X4 a_147_95# a_117_69# a_65_345# w_0_309# sky130_fd_pr__pfet_01v8_hvt ad=2.7e+11p pd=2.54e+06u as=7.884e+11p ps=7.17e+06u w=1e+06u l=150000u
X5 a_629_417# a_391_69# a_117_69# w_0_309# sky130_fd_pr__pfet_01v8_hvt ad=1.344e+11p pd=1.7e+06u as=0p ps=0u w=640000u l=150000u
X6 a_344_417# a_295_247# a_65_345# w_0_309# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=640000u l=150000u
X7 a_65_345# a_117_69# a_147_95# w_0_309# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X8 a_295_247# a_671_69# a_65_345# w_0_309# sky130_fd_pr__pfet_01v8_hvt ad=1.728e+11p pd=1.82e+06u as=0p ps=0u w=640000u l=150000u
X9 a_326_95# a_295_247# a_65_95# VSUBS sky130_fd_pr__nfet_01v8 ad=1.365e+11p pd=1.49e+06u as=0p ps=0u w=420000u l=150000u
X10 a_65_345# a_671_69# a_629_417# w_0_309# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=640000u l=150000u
X11 a_117_69# a_391_69# a_326_95# VSUBS sky130_fd_pr__nfet_01v8 ad=3.465e+11p pd=2.49e+06u as=0p ps=0u w=420000u l=150000u
X12 a_65_95# a_117_69# a_147_95# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X13 a_616_95# a_487_233# a_117_69# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
.ends

.subckt cs__clkbuf_8 VSUBS a_65_345# w_0_309# a_59_228# a_65_95# a_320_95#
X0 a_65_95# a_148_95# a_320_95# VSUBS sky130_fd_pr__nfet_01v8 ad=6.951e+11p pd=8.35e+06u as=4.704e+11p ps=5.6e+06u w=420000u l=150000u
X1 a_320_95# a_148_95# a_65_95# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X2 a_65_95# a_148_95# a_320_95# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X3 a_65_345# a_148_95# a_320_95# w_0_309# sky130_fd_pr__pfet_01v8_hvt ad=1.65e+12p pd=1.53e+07u as=1.12e+12p ps=1.024e+07u w=1e+06u l=150000u
X4 a_320_95# a_148_95# a_65_345# w_0_309# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X5 a_320_95# a_148_95# a_65_95# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X6 a_320_95# a_148_95# a_65_95# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X7 a_65_345# a_148_95# a_320_95# w_0_309# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X8 a_148_95# a_59_228# a_65_345# w_0_309# sky130_fd_pr__pfet_01v8_hvt ad=2.8e+11p pd=2.56e+06u as=0p ps=0u w=1e+06u l=150000u
X9 a_320_95# a_148_95# a_65_345# w_0_309# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X10 a_65_345# a_148_95# a_320_95# w_0_309# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X11 a_65_95# a_148_95# a_320_95# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X12 a_65_345# a_59_228# a_148_95# w_0_309# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X13 a_320_95# a_148_95# a_65_345# w_0_309# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X14 a_320_95# a_148_95# a_65_95# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X15 a_65_95# a_148_95# a_320_95# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X16 a_148_95# a_59_228# a_65_95# VSUBS sky130_fd_pr__nfet_01v8 ad=1.176e+11p pd=1.4e+06u as=0p ps=0u w=420000u l=150000u
X17 a_65_95# a_59_228# a_148_95# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X18 a_320_95# a_148_95# a_65_345# w_0_309# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X19 a_65_345# a_148_95# a_320_95# w_0_309# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
.ends

.subckt cs__dfrbp_1 VSUBS a_147_411# a_147_95# a_60_247# w_0_309# a_1748_345# a_369_308#
+ a_885_69#
X0 a_677_95# a_231_95# a_581_95# VSUBS sky130_fd_pr__nfet_01v8 ad=2.802e+11p pd=2.2e+06u as=1.188e+11p ps=1.38e+06u w=360000u l=150000u
X1 a_1321_69# a_1146_95# a_1500_95# VSUBS sky130_fd_pr__nfet_01v8 ad=1.092e+11p pd=1.36e+06u as=1.281e+11p ps=1.45e+06u w=420000u l=150000u
X2 a_689_461# a_65_95# a_581_95# w_0_309# sky130_fd_pr__pfet_01v8_hvt ad=3.402e+11p pd=3.3e+06u as=1.449e+11p ps=1.53e+06u w=420000u l=150000u
X3 a_843_95# a_799_337# a_677_95# VSUBS sky130_fd_pr__nfet_01v8 ad=8.82e+10p pd=1.26e+06u as=0p ps=0u w=420000u l=150000u
X4 a_581_95# a_231_95# a_486_95# w_0_309# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=1.302e+11p ps=1.46e+06u w=420000u l=150000u
X5 a_147_95# a_885_69# a_843_95# VSUBS sky130_fd_pr__nfet_01v8 ad=1.2225e+12p pd=1.139e+07u as=0p ps=0u w=420000u l=150000u
X6 a_147_95# a_60_247# a_65_95# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.092e+11p ps=1.36e+06u w=420000u l=150000u
X7 a_486_95# a_369_308# a_147_411# w_0_309# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=1.5393e+12p ps=1.452e+07u w=420000u l=150000u
X8 a_147_411# a_60_247# a_65_95# w_0_309# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=1.664e+11p ps=1.8e+06u w=640000u l=150000u
X9 a_147_411# a_799_337# a_689_461# w_0_309# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X10 a_1748_345# a_1321_69# a_147_95# VSUBS sky130_fd_pr__nfet_01v8 ad=1.69e+11p pd=1.82e+06u as=0p ps=0u w=650000u l=150000u
X11 a_147_95# a_1321_69# a_1255_95# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.338e+11p ps=1.5e+06u w=420000u l=150000u
X12 a_689_461# a_885_69# a_147_411# w_0_309# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X13 a_1500_95# a_885_69# a_147_95# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X14 a_147_95# a_1321_69# a_1885_95# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.092e+11p ps=1.36e+06u w=420000u l=150000u
X15 a_231_95# a_65_95# a_147_411# w_0_309# sky130_fd_pr__pfet_01v8_hvt ad=1.664e+11p pd=1.8e+06u as=0p ps=0u w=640000u l=150000u
X16 a_147_411# a_1146_95# a_1321_69# w_0_309# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=1.134e+11p ps=1.38e+06u w=420000u l=150000u
X17 a_2064_95# a_1885_95# a_147_95# VSUBS sky130_fd_pr__nfet_01v8 ad=1.69e+11p pd=1.82e+06u as=0p ps=0u w=650000u l=150000u
X18 a_147_411# a_1321_69# a_1885_95# w_0_309# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=1.664e+11p ps=1.8e+06u w=640000u l=150000u
X19 a_1255_95# a_65_95# a_1146_95# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.422e+11p ps=1.51e+06u w=360000u l=150000u
X20 a_1308_461# a_231_95# a_1146_95# w_0_309# sky130_fd_pr__pfet_01v8_hvt ad=1.134e+11p pd=1.38e+06u as=1.176e+11p ps=1.4e+06u w=420000u l=150000u
X21 a_1146_95# a_65_95# a_799_337# w_0_309# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.583e+11p ps=2.37e+06u w=420000u l=150000u
X22 a_1321_69# a_885_69# a_147_411# w_0_309# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X23 a_2064_95# a_1885_95# a_147_411# w_0_309# sky130_fd_pr__pfet_01v8_hvt ad=2.6e+11p pd=2.52e+06u as=0p ps=0u w=1e+06u l=150000u
X24 a_486_95# a_369_308# a_147_95# VSUBS sky130_fd_pr__nfet_01v8 ad=1.32e+11p pd=1.49e+06u as=0p ps=0u w=420000u l=150000u
X25 a_147_411# a_1321_69# a_1308_461# w_0_309# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X26 a_799_337# a_581_95# a_147_411# w_0_309# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=840000u l=150000u
X27 a_1748_345# a_1321_69# a_147_411# w_0_309# sky130_fd_pr__pfet_01v8_hvt ad=2.8e+11p pd=2.56e+06u as=0p ps=0u w=1e+06u l=150000u
X28 a_1146_95# a_231_95# a_799_337# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.998e+11p ps=1.97e+06u w=360000u l=150000u
X29 a_231_95# a_65_95# a_147_95# VSUBS sky130_fd_pr__nfet_01v8 ad=1.092e+11p pd=1.36e+06u as=0p ps=0u w=420000u l=150000u
X30 a_799_337# a_581_95# a_147_95# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=640000u l=150000u
X31 a_581_95# a_65_95# a_486_95# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=360000u l=150000u
.ends

.subckt cs__inv_1 VSUBS a_102_247# a_106_345# w_0_309# a_188_95# a_106_95#
X0 a_188_95# a_102_247# a_106_95# VSUBS sky130_fd_pr__nfet_01v8 ad=1.69e+11p pd=1.82e+06u as=1.69e+11p ps=1.82e+06u w=650000u l=150000u
X1 a_188_95# a_102_247# a_106_345# w_0_309# sky130_fd_pr__pfet_01v8_hvt ad=2.6e+11p pd=2.52e+06u as=2.6e+11p ps=2.52e+06u w=1e+06u l=150000u
.ends

.subckt cs__unit VSUBS cs__inv_1_0/w_0_309# cs__inv_1_0/a_102_247# cs__dfrbp_1_0/a_1748_345#
+ cs__inv_1_0/a_106_345# cs__inv_1_0/a_106_95# cs__dfrbp_1_0/a_885_69# cs__dfrbp_1_0/a_369_308#
+ cs__inv_1_0/a_188_95# cs__dfrbp_1_0/a_60_247#
Xcs__dfrbp_1_0 VSUBS cs__inv_1_0/a_106_345# cs__inv_1_0/a_106_95# cs__dfrbp_1_0/a_60_247#
+ cs__inv_1_0/w_0_309# cs__dfrbp_1_0/a_1748_345# cs__dfrbp_1_0/a_369_308# cs__dfrbp_1_0/a_885_69#
+ cs__dfrbp_1
Xcs__decap_4_0 VSUBS cs__inv_1_0/a_106_95# cs__inv_1_0/w_0_309# cs__inv_1_0/a_106_345#
+ cs__decap_4
Xcs__decap_4_1 VSUBS cs__inv_1_0/a_106_95# cs__inv_1_0/w_0_309# cs__inv_1_0/a_106_345#
+ cs__decap_4
Xcs__inv_1_0 VSUBS cs__inv_1_0/a_102_247# cs__inv_1_0/a_106_345# cs__inv_1_0/w_0_309#
+ cs__inv_1_0/a_188_95# cs__inv_1_0/a_106_95# cs__inv_1
.ends

.subckt cs__clkdiv VSUBS m3_0_386# m2_1904_1224# m3_0_0# m1_2257_2783# m1_60_1161#
Xcs__unit_0 VSUBS m3_0_0# m1_531_2647# m1_531_2647# m3_0_0# m3_0_386# m2_1904_1224#
+ m1_816_2396# m1_816_2396# m1_531_2103# cs__unit
Xcs__unit_1 VSUBS m3_0_0# m1_531_2103# m1_531_2103# m3_0_0# m3_0_386# m2_1904_1224#
+ m1_803_1765# m1_803_1765# m1_531_1557# cs__unit
Xcs__unit_2 VSUBS m3_0_0# m1_531_1557# m1_531_1557# m3_0_0# m3_0_386# m2_1904_1224#
+ m1_816_1306# m1_816_1306# m1_60_1161# cs__unit
Xcs__unit_3 VSUBS m3_0_0# m1_2257_2783# m1_2257_2783# m3_0_0# m3_0_386# m2_1904_1224#
+ m1_803_2852# m1_803_2852# m1_531_2647# cs__unit
.ends

.subckt clksel VSUBS m3_0_3734# m3_0_3380# m3_0_386# m3_4380_3856# m3_0_4334# m3_0_3250#
+ m3_0_0# m3_0_3884#
Xcs__decap_4_0 VSUBS m3_0_386# m3_0_0# m3_0_0# cs__decap_4
Xcs__decap_4_1 VSUBS m3_0_386# m3_0_0# m3_0_0# cs__decap_4
Xcs__mux2_0 VSUBS m1_2006_4033# m3_0_0# m3_0_4334# m3_0_0# m2_2370_3419# m3_0_386#
+ m1_220_1161# cs__mux2
Xcs__mux2_1 VSUBS m1_220_1161# m3_0_0# m3_0_3380# m3_0_0# m3_0_3734# m3_0_386# m3_0_3884#
+ cs__mux2
Xcs__clkbuf_8_0 VSUBS m3_0_0# m3_0_0# m1_2006_4033# m3_0_386# m3_4380_3856# cs__clkbuf_8
Xcs__clkdiv_0 VSUBS m3_0_386# m3_0_3250# m3_0_0# m2_2370_3419# m1_220_1161# cs__clkdiv
.ends

.subckt mdo__cdec VSUBS m3_n1050_n1300# c1_n950_n1200#
X0 c1_n950_n1200# m3_n1050_n1300# sky130_fd_pr__cap_mim_m3_1 l=1.2e+07u w=9e+06u
.ends

.subckt module_decap_open VSUBS m3_0_380# m3_0_0#
Xmdo__cdec_0 VSUBS m3_0_380# m3_0_0# mdo__cdec
Xmdo__cdec_1 VSUBS m3_0_380# m3_0_0# mdo__cdec
.ends

.subckt main VSUBS m3_29611_3856# m3_0_8071# m2_0_52504# m3_0_6765# m2_0_36521# m4_136_0#
+ m4_37496_0# m3_24805_3734# m2_0_38564# m3_4861_380# m3_0_7911# m4_2079_31107# m3_0_7751#
+ m2_0_36321# m3_0_52730#
Xmodule_decap_25 VSUBS m4_136_0# m3_4861_380# module_decap
Xmodule_decap_14 VSUBS m4_136_0# m3_4861_380# module_decap
Xmodule_decap_26 VSUBS m4_136_0# m3_4861_380# module_decap
Xmodule_decap_15 VSUBS m4_136_0# m3_4861_380# module_decap
Xmodule_decap_27 VSUBS m4_136_0# m3_4861_380# module_decap
Xmodule_decap_16 VSUBS m4_136_0# m3_4861_380# module_decap
Xinverter_0 VSUBS m4_2079_31107# m3_4861_380# m2_0_52504# m1_8103_51232# inverter
Xmodule_decap_28 VSUBS m4_136_0# m3_4861_380# module_decap
Xmodule_decap_17 VSUBS m4_136_0# m3_4861_380# module_decap
Xmodule_decap_29 VSUBS m4_136_0# m3_4861_380# module_decap
Xmodule_decap_18 VSUBS m4_136_0# m3_4861_380# module_decap
Xmodule_decap_19 VSUBS m4_136_0# m3_4861_380# module_decap
Xbias_basis_current_0 VSUBS m4_2079_31107# m3_4861_380# m3_10333_45058# m3_10450_49863#
+ bias_basis_current
Xbandgap_0 VSUBS m4_2079_31107# m3_4861_380# m3_9177_52208# m3_10450_49863# bandgap
Xmodule_decap_0 VSUBS m4_37496_0# m3_4861_380# module_decap
Xmodule_decap_1 VSUBS m4_37496_0# m3_4861_380# module_decap
Xregulator_0 VSUBS m3_4861_380# m4_2079_31107# m2_0_36521# m2_0_37724# m2_0_38284#
+ m4_37496_0# regulator
Xbias_0 VSUBS m2_0_38844# m2_0_37304# m4_2079_31107# m2_0_38004# m2_0_38704# m2_0_37584#
+ m3_4861_380# m2_0_38284# m2_3852_39124# m2_0_38984# m2_0_37864# m3_10333_45058#
+ m2_0_38564# m2_0_37444# m2_0_37724# m2_0_38144# m2_0_38424# bias
Xmodule_decap_2 VSUBS m4_37496_0# m3_4861_380# module_decap
Xregulator_1 VSUBS m3_4861_380# m4_2079_31107# m2_0_36321# m2_0_37864# m2_0_38704#
+ m4_136_0# regulator
Xmodule_decap_3 VSUBS m4_37496_0# m3_4861_380# module_decap
Xrosc_0 VSUBS m4_37496_0# m3_0_7751# m3_4861_380# m3_24542_3884# m4_136_0# m3_0_6765#
+ m2_0_38844# m3_4861_380# rosc
Xmodule_decap_4 VSUBS m4_37496_0# m3_4861_380# module_decap
Xpassgate_0 VSUBS m2_3852_39124# m2_0_52504# m3_4861_380# m4_2079_31107# m3_0_52730#
+ passgate
Xmodule_decap_5 VSUBS m4_37496_0# m3_4861_380# module_decap
Xpassgate_1 VSUBS m2_3852_39124# m1_8103_51232# m3_4861_380# m4_2079_31107# m3_9177_52208#
+ passgate
Xmodule_decap_6 VSUBS m4_37496_0# m3_4861_380# module_decap
Xclksel_0 VSUBS m3_24805_3734# m3_0_7911# m3_4861_380# m3_29611_3856# m3_0_8071# m3_0_7751#
+ m4_37496_0# m3_24542_3884# clksel
Xmodule_decap_7 VSUBS m4_37496_0# m3_4861_380# module_decap
Xmodule_decap_8 VSUBS m4_37496_0# m3_4861_380# module_decap
Xmodule_decap_9 VSUBS m4_37496_0# m3_4861_380# module_decap
Xmodule_decap_open_0 VSUBS m3_4861_380# m4_37496_0# module_decap_open
Xmodule_decap_30 VSUBS m4_136_0# m3_4861_380# module_decap
Xmodule_decap_open_1 VSUBS m3_4861_380# m4_136_0# module_decap_open
Xmodule_decap_31 VSUBS m4_136_0# m3_4861_380# module_decap
Xmodule_decap_20 VSUBS m4_136_0# m3_4861_380# module_decap
Xmodule_decap_32 VSUBS m4_136_0# m3_4861_380# module_decap
Xmodule_decap_10 VSUBS m4_37496_0# m3_4861_380# module_decap
Xmodule_decap_21 VSUBS m4_136_0# m3_4861_380# module_decap
Xmodule_decap_open_2 VSUBS m3_4861_380# m4_136_0# module_decap_open
Xmodule_decap_open_3 VSUBS m3_4861_380# m4_136_0# module_decap_open
Xmodule_decap_11 VSUBS m4_37496_0# m3_4861_380# module_decap
Xmodule_decap_22 VSUBS m4_136_0# m3_4861_380# module_decap
Xmodule_decap_23 VSUBS m4_136_0# m3_4861_380# module_decap
Xmodule_decap_12 VSUBS m4_37496_0# m3_4861_380# module_decap
Xmodule_decap_24 VSUBS m4_136_0# m3_4861_380# module_decap
Xmodule_decap_13 VSUBS m4_37496_0# m3_4861_380# module_decap
.ends

.subckt lat__M1 VSUBS a_40_n109# a_n40_n197# a_n98_n109#
X0 a_40_n109# a_n40_n197# a_n98_n109# VSUBS sky130_fd_pr__nfet_01v8_lvt ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=400000u
.ends

.subckt latinv__M1 VSUBS a_n98_n171# a_n40_n197# a_40_n171#
X0 a_40_n171# a_n40_n197# a_n98_n171# VSUBS sky130_fd_pr__nfet_01v8_lvt ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=400000u
.ends

.subckt latinv__M2 VSUBS a_n98_n104# w_n236_n324# a_40_n104# a_n40_n201#
X0 a_40_n104# a_n40_n201# a_n98_n104# w_n236_n324# sky130_fd_pr__pfet_01v8_lvt ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=400000u
.ends

.subckt lat__inv_lvt VSUBS m1_170_505# m2_289_257# latinv__M2_0/a_n98_n104# latinv__M2_0/w_n236_n324#
+ latinv__M1_0/a_n98_n171#
Xlatinv__M1_0 VSUBS latinv__M1_0/a_n98_n171# m1_170_505# m2_289_257# latinv__M1
Xlatinv__M2_0 VSUBS latinv__M2_0/a_n98_n104# latinv__M2_0/w_n236_n324# m2_289_257#
+ m1_170_505# latinv__M2
.ends

.subckt lat__M2 VSUBS a_40_n109# a_n40_n197# a_n98_n109#
X0 a_40_n109# a_n40_n197# a_n98_n109# VSUBS sky130_fd_pr__nfet_01v8_lvt ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=400000u
.ends

.subckt latch VSUBS m2_160_n38# m1_1425_623# m1_2083_623# m1_83_623# w_53_680#
Xlat__M1_0 VSUBS m2_160_n38# m1_458_623# m1_881_447# lat__M1
Xlat__inv_lvt_0 VSUBS m1_2083_623# m1_1673_493# w_53_680# w_53_680# m2_160_n38# lat__inv_lvt
Xlat__inv_lvt_1 VSUBS m1_83_623# m1_458_623# w_53_680# w_53_680# m2_160_n38# lat__inv_lvt
Xlat__inv_lvt_2 VSUBS m1_881_447# m1_1425_623# w_53_680# w_53_680# m2_160_n38# lat__inv_lvt
Xlat__inv_lvt_3 VSUBS m1_1425_623# m1_881_447# w_53_680# w_53_680# m2_160_n38# lat__inv_lvt
Xlat__M2_0 VSUBS m1_1425_623# m1_1673_493# m2_160_n38# lat__M2
.ends

.subckt dac__inv2 VSUBS a_67_55# a_149_55# a_59_207# a_67_305# w_0_269#
X0 a_67_305# a_59_207# a_149_55# w_0_269# sky130_fd_pr__pfet_01v8_hvt ad=5.2e+11p pd=5.04e+06u as=2.7e+11p ps=2.54e+06u w=1e+06u l=150000u
X1 a_67_55# a_59_207# a_149_55# VSUBS sky130_fd_pr__nfet_01v8 ad=3.38e+11p pd=3.64e+06u as=1.755e+11p ps=1.84e+06u w=650000u l=150000u
X2 a_149_55# a_59_207# a_67_55# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X3 a_149_55# a_59_207# a_67_305# w_0_269# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
.ends

.subckt dacswt__M3 VSUBS a_n40_n162# a_n98_n136# a_40_n136# w_n134_n198#
X0 a_40_n136# a_n40_n162# a_n98_n136# w_n134_n198# sky130_fd_pr__pfet_01v8_lvt ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=400000u
.ends

.subckt dacswt__cbs VSUBS m3_n650_n600# c1_n550_n500#
X0 c1_n550_n500# m3_n650_n600# sky130_fd_pr__cap_mim_m3_1 l=5e+06u w=5e+06u
.ends

.subckt dacswt__MS2 VSUBS a_n98_n131# a_n40_n157# a_40_n131# w_n124_n157#
X0 a_40_n131# a_n40_n157# a_n98_n131# VSUBS sky130_fd_pr__nfet_01v8_lvt ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=400000u
.ends

.subckt dacswt__M1 VSUBS a_n98_n131# a_n40_n157# a_40_n131# w_n124_n157#
X0 a_40_n131# a_n40_n157# a_n98_n131# VSUBS sky130_fd_pr__nfet_01v8_lvt ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=400000u
.ends

.subckt dacswtinv__MP VSUBS a_n40_n161# a_n98_n64# w_n236_n284# a_40_n64#
X0 a_40_n64# a_n40_n161# a_n98_n64# w_n236_n284# sky130_fd_pr__pfet_01v8_lvt ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=400000u
.ends

.subckt dacswtinv__MN VSUBS w_n226_n269# a_n98_n131# a_n40_n157# a_40_n131#
X0 a_40_n131# a_n40_n157# a_n98_n131# VSUBS sky130_fd_pr__nfet_01v8_lvt ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=400000u
.ends

.subckt dacswt__inv_lvt VSUBS m1_30_694# m1_170_545# m2_127_0# m2_289_297#
Xdacswtinv__MP_0 VSUBS m1_170_545# m1_30_694# m1_30_694# m2_289_297# dacswtinv__MP
Xdacswtinv__MN_0 VSUBS m2_127_0# m2_127_0# m1_170_545# m2_289_297# dacswtinv__MN
.ends

.subckt dacswt__M4 VSUBS a_n40_n162# a_n98_n136# a_40_n136# w_n134_n198#
X0 a_40_n136# a_n40_n162# a_n98_n136# w_n134_n198# sky130_fd_pr__pfet_01v8_lvt ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=400000u
.ends

.subckt dacswt__M2 VSUBS a_n98_n131# a_n40_n157# a_40_n131# w_n124_n157#
X0 a_40_n131# a_n40_n157# a_n98_n131# VSUBS sky130_fd_pr__nfet_01v8_lvt ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=400000u
.ends

.subckt dacswt__MS1 VSUBS a_n98_n131# a_n40_n157# a_40_n131# w_n124_n157#
X0 a_40_n131# a_n40_n157# a_n98_n131# VSUBS sky130_fd_pr__nfet_01v8_lvt ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=400000u
.ends

.subckt dacswt__MS VSUBS w_n134_n157# a_n108_n131# a_n50_n157# a_50_n131#
X0 a_50_n131# a_n50_n157# a_n108_n131# VSUBS sky130_fd_pr__nfet_01v8_lvt ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
.ends

.subckt dac__sw_top VSUBS m2_332_n273# m2_2288_507# m1_1924_n925# m2_332_511# m2_332_n1129#
Xdacswt__M3_0 VSUBS m1_1333_n747# m4_2064_377# m2_332_511# m4_2064_377# dacswt__M3
Xdacswt__cbs_0 VSUBS m4_1856_n964# m4_2064_377# dacswt__cbs
Xdacswt__MS2_0 VSUBS dacswt__MS1_0/a_40_n131# m2_908_n273# m2_332_n1129# dacswt__MS_0/w_n134_n157#
+ dacswt__MS2
Xdacswt__cbs_1 VSUBS m4_1856_n964# m4_2064_377# dacswt__cbs
Xdacswt__M1_0 VSUBS m4_1856_n964# m1_1333_n747# m1_1924_n925# dacswt__MS_0/w_n134_n157#
+ dacswt__M1
Xdacswt__cbs_3 VSUBS m4_1856_n964# m4_2064_377# dacswt__cbs
Xdacswt__cbs_2 VSUBS m4_1856_n964# m4_2064_377# dacswt__cbs
Xdacswt__inv_lvt_0 VSUBS m2_332_511# m2_332_n273# m2_332_n1129# m2_908_n273# dacswt__inv_lvt
Xdacswt__M4_0 VSUBS m2_908_n273# m1_1333_n747# m4_2064_377# m4_2064_377# dacswt__M4
Xdacswt__M2_0 VSUBS m2_332_n1129# m2_908_n273# m4_1856_n964# dacswt__MS_0/w_n134_n157#
+ dacswt__M2
Xdacswt__MS1_0 VSUBS m1_1333_n747# m2_332_511# dacswt__MS1_0/a_40_n131# dacswt__MS_0/w_n134_n157#
+ dacswt__MS1
Xdacswt__MS_0 VSUBS dacswt__MS_0/w_n134_n157# m1_1924_n925# m1_1333_n747# m2_2288_507#
+ dacswt__MS
.ends

.subckt DAC VSUBS m2_n2831_1711# m2_n2831_883# m2_n2831_2263# m4_37925_2722# m2_39240_275#
+ m2_n2831_1159# m3_n2831_n855# dac__carray_0/m2_664_2764# m2_n2831_2539# m2_n2831_1987#
+ m2_40096_n434# m2_n2831_607# m4_40296_2308# m2_n2831_1435# m2_38456_n434# m3_n2831_n475#
+ m2_n2831_2815#
Xdac__inv2_0 VSUBS m3_n2831_n475# m3_n1610_2448# m2_n2831_2539# m3_n2831_n855# m3_n2831_n855#
+ dac__inv2
Xdac__inv2_1 VSUBS m3_n2831_n475# m3_n1610_2724# m2_n2831_2815# m3_n2831_n855# m3_n2831_n855#
+ dac__inv2
Xdac__inv2_3 VSUBS m3_n2831_n475# m3_n1610_1896# m2_n2831_1987# m3_n2831_n855# m3_n2831_n855#
+ dac__inv2
Xdac__inv2_2 VSUBS m3_n2831_n475# m3_n1610_2172# m2_n2831_2263# m3_n2831_n855# m3_n2831_n855#
+ dac__inv2
Xdac__inv2_4 VSUBS m3_n2831_n475# m3_n1610_1068# m2_n2831_1159# m3_n2831_n855# m3_n2831_n855#
+ dac__inv2
Xdac__inv2_5 VSUBS m3_n2831_n475# m3_n1610_792# m2_n2831_883# m3_n2831_n855# m3_n2831_n855#
+ dac__inv2
Xdac__inv2_6 VSUBS m3_n2831_n475# m3_n1610_516# m2_n2831_607# m3_n2831_n855# m3_n2831_n855#
+ dac__inv2
Xdac__inv2_7 VSUBS m3_n2831_n475# m3_n1610_1620# m2_n2831_1711# m3_n2831_n855# m3_n2831_n855#
+ dac__inv2
Xdac__inv2_8 VSUBS m3_n2831_n475# m3_n1610_1344# m2_n2831_1435# m3_n2831_n855# m3_n2831_n855#
+ dac__inv2
Xdac__sw_top_0 VSUBS m2_39240_275# m4_37925_2722# m4_40296_2308# m2_38456_n434# m2_40096_n434#
+ dac__sw_top
.ends

.subckt cmpc__M4 VSUBS a_30_n176# w_n124_n238# a_n33_55# a_n88_n176#
X0 a_30_n176# a_n33_55# a_n88_n176# w_n124_n238# sky130_fd_pr__pfet_01v8 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=300000u
.ends

.subckt cmpc__Ml4 VSUBS a_30_n176# w_n124_n238# a_n33_55# a_n88_n176#
X0 a_30_n176# a_n33_55# a_n88_n176# w_n124_n238# sky130_fd_pr__pfet_01v8 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=300000u
.ends

.subckt cmpc__M2 VSUBS a_30_n176# w_n124_n238# a_n33_55# a_n88_n176#
X0 a_30_n176# a_n33_55# a_n88_n176# w_n124_n238# sky130_fd_pr__pfet_01v8 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=300000u
.ends

.subckt cmpc__Ml2 VSUBS a_n88_n171# a_30_n171# w_n114_n197# a_n33_51#
X0 a_30_n171# a_n33_51# a_n88_n171# VSUBS sky130_fd_pr__nfet_01v8 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=300000u
.ends

.subckt cmpc__Minp VSUBS a_n88_n171# a_30_n171# w_n114_n197# a_n33_51#
X0 a_30_n171# a_n33_51# a_n88_n171# VSUBS sky130_fd_pr__nfet_01v8 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=300000u
.ends

.subckt cmpc__Minn VSUBS a_n88_n171# a_30_n171# w_n114_n197# a_n33_51#
X0 a_30_n171# a_n33_51# a_n88_n171# VSUBS sky130_fd_pr__nfet_01v8 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=300000u
.ends

.subckt cmpc__M3 VSUBS a_30_n176# w_n124_n238# a_n33_55# a_n88_n176#
X0 a_30_n176# a_n33_55# a_n88_n176# w_n124_n238# sky130_fd_pr__pfet_01v8 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=300000u
.ends

.subckt cmpc__Ml3 VSUBS a_30_n176# w_n124_n238# a_n33_55# a_n88_n176#
X0 a_30_n176# a_n33_55# a_n88_n176# w_n124_n238# sky130_fd_pr__pfet_01v8 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=300000u
.ends

.subckt cmpc__M1 VSUBS a_30_n176# w_n124_n238# a_n33_55# a_n88_n176#
X0 a_30_n176# a_n33_55# a_n88_n176# w_n124_n238# sky130_fd_pr__pfet_01v8 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=300000u
.ends

.subckt cmpc__Mdiff VSUBS a_n88_n171# a_30_n171# w_n114_n197# a_n33_51#
X0 a_30_n171# a_n33_51# a_n88_n171# VSUBS sky130_fd_pr__nfet_01v8 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=300000u
.ends

.subckt cmpc__Ml1 VSUBS a_n88_n171# a_30_n171# w_n114_n197# a_n33_51#
X0 a_30_n171# a_n33_51# a_n88_n171# VSUBS sky130_fd_pr__nfet_01v8 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=300000u
.ends

.subckt cmp__comparator_core VSUBS m4_0_1499# m1_213_826# m2_1819_n40# m2_554_3151#
+ m2_349_467# m2_1087_228# m1_1497_826# m4_2056_1499# m2_905_n40#
Xcmpc__M4_0 VSUBS m1_1497_826# w_302_2337# m2_349_467# m2_554_3151# cmpc__M4
Xcmpc__Ml4_0 VSUBS m2_1819_n40# w_302_2337# m2_905_n40# m2_554_3151# cmpc__Ml4
Xcmpc__M2_0 VSUBS m2_905_n40# w_302_2337# m2_349_467# m2_554_3151# cmpc__M2
Xcmpc__Ml2_0 VSUBS m2_1819_n40# m1_1497_826# cmpc__Ml2_0/w_n114_n197# m2_905_n40#
+ cmpc__Ml2
Xcmpc__Minp_0 VSUBS m1_1379_620# m1_1497_826# cmpc__Ml2_0/w_n114_n197# m4_2056_1499#
+ cmpc__Minp
Xcmpc__Minn_0 VSUBS m1_213_826# m1_1379_620# cmpc__Ml2_0/w_n114_n197# m4_0_1499# cmpc__Minn
Xcmpc__M3_0 VSUBS m2_554_3151# w_302_2337# m2_349_467# m2_1819_n40# cmpc__M3
Xcmpc__Ml3_0 VSUBS m2_554_3151# w_302_2337# m2_1819_n40# m2_905_n40# cmpc__Ml3
Xcmpc__M1_0 VSUBS m2_554_3151# w_302_2337# m2_349_467# m1_213_826# cmpc__M1
Xcmpc__Mdiff_0 VSUBS m1_1379_620# m2_1087_228# cmpc__Mdiff_1/w_n114_n197# m2_349_467#
+ cmpc__Mdiff
Xcmpc__Mdiff_1 VSUBS m2_1087_228# m1_1379_620# cmpc__Mdiff_1/w_n114_n197# m2_349_467#
+ cmpc__Mdiff
Xcmpc__Ml1_0 VSUBS m1_213_826# m2_905_n40# cmpc__Ml2_0/w_n114_n197# m2_1819_n40# cmpc__Ml1
.ends

.subckt cmpts__M1 VSUBS a_n33_n197# a_n88_n109# w_n114_n135# a_30_n109#
X0 a_30_n109# a_n33_n197# a_n88_n109# VSUBS sky130_fd_pr__nfet_01v8_lvt ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=300000u
.ends

.subckt cmpt__trim_sw VSUBS m2_12_359# m2_910_n40# m2_2118_n40# m1_1226_409# m1_799_409#
+ m2_1488_n40# m1_136_409# m2_365_n40# m2_1186_n40# m1_1771_409# m1_1462_409#
Xcmpts__M1_1 VSUBS m2_2118_n40# m1_1771_409# cmpts__M1_8/w_n114_n135# m2_12_359# cmpts__M1
Xcmpts__M1_2 VSUBS m2_2118_n40# m2_12_359# cmpts__M1_8/w_n114_n135# m1_1771_409# cmpts__M1
Xcmpts__M1_3 VSUBS m2_2118_n40# m1_1771_409# cmpts__M1_8/w_n114_n135# m2_12_359# cmpts__M1
Xcmpts__M1_4 VSUBS m2_2118_n40# m2_12_359# cmpts__M1_8/w_n114_n135# m1_1771_409# cmpts__M1
Xcmpts__M1_5 VSUBS m2_2118_n40# m2_12_359# cmpts__M1_8/w_n114_n135# m1_1771_409# cmpts__M1
Xcmpts__M1_6 VSUBS m2_2118_n40# m1_1771_409# cmpts__M1_8/w_n114_n135# m2_12_359# cmpts__M1
Xcmpts__M1_8 VSUBS m2_2118_n40# m2_12_359# cmpts__M1_8/w_n114_n135# m1_1771_409# cmpts__M1
Xcmpts__M1_7 VSUBS m2_2118_n40# m1_1771_409# cmpts__M1_8/w_n114_n135# m2_12_359# cmpts__M1
Xcmpts__M1_9 VSUBS m2_1488_n40# m2_12_359# cmpts__M1_9/w_n114_n135# m1_1462_409# cmpts__M1
Xcmpts__M1_10 VSUBS m2_365_n40# m2_12_359# cmpts__M1_13/w_n114_n135# m1_136_409# cmpts__M1
Xcmpts__M1_11 VSUBS m2_365_n40# m1_136_409# cmpts__M1_13/w_n114_n135# m2_12_359# cmpts__M1
Xcmpts__M1_12 VSUBS m2_365_n40# m2_12_359# cmpts__M1_13/w_n114_n135# m1_136_409# cmpts__M1
Xcmpts__M1_13 VSUBS m2_365_n40# m1_136_409# cmpts__M1_13/w_n114_n135# m2_12_359# cmpts__M1
Xcmpts__M1_14 VSUBS m2_910_n40# m1_799_409# cmpts__M1_15/w_n114_n135# m2_12_359# cmpts__M1
Xcmpts__M1_15 VSUBS m2_910_n40# m2_12_359# cmpts__M1_15/w_n114_n135# m1_799_409# cmpts__M1
Xcmpts__M1_0 VSUBS m2_1186_n40# m1_1226_409# cmpts__M1_9/w_n114_n135# m2_12_359# cmpts__M1
.ends

.subckt cmp__trim VSUBS cmpt__trim_sw_0/m2_910_n40# cmpt__trim_sw_0/m2_1488_n40# m2_19_526#
+ cmpt__trim_sw_0/m2_365_n40# cmpt__trim_sw_0/m2_1186_n40# cmpt__trim_array_0/cmpt__C0_9/m2_0_814#
+ cmpt__trim_sw_0/m2_2118_n40#
Xcmpt__trim_sw_0 VSUBS m2_19_526# cmpt__trim_sw_0/m2_910_n40# cmpt__trim_sw_0/m2_2118_n40#
+ m2_1288_905# m1_799_686# cmpt__trim_sw_0/m2_1488_n40# m1_136_709# cmpt__trim_sw_0/m2_365_n40#
+ cmpt__trim_sw_0/m2_1186_n40# m2_952_1626# m2_1400_905# cmpt__trim_sw
.ends

.subckt comparator VSUBS m3_0_194# m2_380_n40# m2_9414_2086# m2_5469_n40# m2_9414_2362#
+ cmp__comparator_core_0/m4_2056_1499# m2_9414_2907# m1_3512_n40# m3_0_34# cmp__comparator_core_0/m4_0_1499#
+ m2_500_n40# m2_9414_1784# m2_620_n40# m2_140_n40# m2_4555_n40# m2_260_n40# m2_9336_1154#
Xcmp__comparator_core_0 VSUBS cmp__comparator_core_0/m4_0_1499# m1_3350_1365# m2_5469_n40#
+ m3_0_194# m1_3512_n40# m3_0_34# m1_6195_1365# cmp__comparator_core_0/m4_2056_1499#
+ m2_4555_n40# cmp__comparator_core
Xcmp__trim_0 VSUBS m2_260_n40# m2_500_n40# m3_0_34# m2_140_n40# m2_380_n40# m1_3350_1365#
+ m2_620_n40# cmp__trim
Xcmp__trim_1 VSUBS m2_9414_2362# m2_9414_1784# m3_0_34# m2_9414_2907# m2_9414_2086#
+ m1_6195_1365# m2_9336_1154# cmp__trim
.ends

.subckt sky130_fd_sc_hd__decap_4 VSUBS a_21_225# w_n38_261# a_27_323#
X0 a_27_323# a_21_225# a_27_323# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=4.524e+11p pd=4.52e+06u as=0p ps=0u w=870000u l=1.05e+06u
X1 a_21_225# a_27_323# a_21_225# VSUBS sky130_fd_pr__nfet_01v8 ad=2.86e+11p pd=3.24e+06u as=0p ps=0u w=550000u l=1.05e+06u
.ends

.subckt sky130_fd_sc_hd__decap_8 VSUBS a_27_47# w_n38_261# a_27_323#
X0 a_27_323# a_27_47# a_27_323# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=4.524e+11p pd=4.52e+06u as=0p ps=0u w=870000u l=2.89e+06u
X1 a_27_47# a_27_323# a_27_47# VSUBS sky130_fd_pr__nfet_01v8 ad=2.86e+11p pd=3.24e+06u as=0p ps=0u w=550000u l=2.89e+06u
.ends

.subckt sky130_fd_sc_hd__inv_2 VSUBS a_29_297# a_21_199# a_29_47# a_111_47# w_n38_261#
X0 a_29_47# a_21_199# a_111_47# VSUBS sky130_fd_pr__nfet_01v8 ad=3.38e+11p pd=3.64e+06u as=1.755e+11p ps=1.84e+06u w=650000u l=150000u
X1 a_111_47# a_21_199# a_29_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=2.7e+11p pd=2.54e+06u as=5.2e+11p ps=5.04e+06u w=1e+06u l=150000u
X2 a_111_47# a_21_199# a_29_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X3 a_29_297# a_21_199# a_111_47# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
.ends

.subckt sky130_fd_sc_hd__dfstp_1 VSUBS a_728_163# a_344_201# a_1779_47# a_109_363#
+ a_109_47# a_22_214# w_n38_261#
X0 a_109_363# a_652_21# a_562_413# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=1.3171e+12p pd=1.335e+07u as=1.89e+11p ps=1.74e+06u w=420000u l=150000u
X1 a_109_47# a_728_163# a_1296_47# VSUBS sky130_fd_pr__nfet_01v8 ad=9.868e+11p pd=1.019e+07u as=9.66e+10p ps=1.3e+06u w=420000u l=150000u
X2 a_476_47# a_193_47# a_381_47# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=1.134e+11p pd=1.38e+06u as=2.499e+11p ps=2.35e+06u w=420000u l=150000u
X3 a_109_363# a_1032_413# a_1602_47# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=1.664e+11p ps=1.8e+06u w=640000u l=150000u
X4 a_109_363# a_1182_261# a_1140_413# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=8.82e+10p ps=1.26e+06u w=420000u l=150000u
X5 a_1224_47# a_27_47# a_1032_413# VSUBS sky130_fd_pr__nfet_01v8 ad=8.82e+10p pd=1.26e+06u as=1.386e+11p ps=1.5e+06u w=420000u l=150000u
X6 a_1182_261# a_1032_413# a_109_47# VSUBS sky130_fd_pr__nfet_01v8 ad=1.404e+11p pd=1.6e+06u as=0p ps=0u w=540000u l=150000u
X7 a_562_413# a_27_47# a_476_47# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X8 a_476_47# a_27_47# a_381_47# VSUBS sky130_fd_pr__nfet_01v8 ad=1.44e+11p pd=1.52e+06u as=1.87e+11p ps=1.93e+06u w=360000u l=150000u
X9 a_1056_47# a_476_47# a_109_47# VSUBS sky130_fd_pr__nfet_01v8 ad=8.82e+10p pd=1.26e+06u as=0p ps=0u w=420000u l=150000u
X10 a_109_47# a_1032_413# a_1602_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.092e+11p ps=1.36e+06u w=420000u l=150000u
X11 a_1032_413# a_193_47# a_1056_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X12 a_652_21# a_728_163# a_109_363# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=1.134e+11p pd=1.38e+06u as=0p ps=0u w=420000u l=150000u
X13 a_652_21# a_476_47# a_796_47# VSUBS sky130_fd_pr__nfet_01v8 ad=1.092e+11p pd=1.36e+06u as=8.82e+10p ps=1.26e+06u w=420000u l=150000u
X14 a_956_413# a_476_47# a_109_363# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=9.66e+10p pd=1.3e+06u as=0p ps=0u w=420000u l=150000u
X15 a_109_47# a_652_21# a_586_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.341e+11p ps=1.5e+06u w=420000u l=150000u
X16 a_381_47# a_344_201# a_109_363# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=840000u l=150000u
X17 a_109_363# a_476_47# a_652_21# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X18 a_1140_413# a_193_47# a_1032_413# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.73e+11p ps=2.98e+06u w=420000u l=150000u
X19 a_1779_47# a_1602_47# a_109_47# VSUBS sky130_fd_pr__nfet_01v8 ad=1.69e+11p pd=1.82e+06u as=0p ps=0u w=650000u l=150000u
X20 a_586_47# a_193_47# a_476_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=360000u l=150000u
X21 a_109_363# a_728_163# a_1032_413# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X22 a_193_47# a_27_47# a_109_47# VSUBS sky130_fd_pr__nfet_01v8 ad=1.092e+11p pd=1.36e+06u as=0p ps=0u w=420000u l=150000u
X23 a_1032_413# a_27_47# a_956_413# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X24 a_109_47# a_22_214# a_27_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.092e+11p ps=1.36e+06u w=420000u l=150000u
X25 a_109_363# a_22_214# a_27_47# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=1.664e+11p ps=1.8e+06u w=640000u l=150000u
X26 a_1182_261# a_1032_413# a_109_363# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=2.184e+11p pd=2.2e+06u as=0p ps=0u w=840000u l=150000u
X27 a_1296_47# a_1182_261# a_1224_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X28 a_193_47# a_27_47# a_109_363# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=1.664e+11p pd=1.8e+06u as=0p ps=0u w=640000u l=150000u
X29 a_381_47# a_344_201# a_109_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=640000u l=150000u
X30 a_796_47# a_728_163# a_109_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X31 a_1779_47# a_1602_47# a_109_363# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=2.6e+11p pd=2.52e+06u as=0p ps=0u w=1e+06u l=150000u
.ends

.subckt sky130_fd_sc_hd__decap_6 VSUBS a_27_47# w_n38_261# a_27_323#
X0 a_27_323# a_27_47# a_27_323# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=4.524e+11p pd=4.52e+06u as=0p ps=0u w=870000u l=1.97e+06u
X1 a_27_47# a_27_323# a_27_47# VSUBS sky130_fd_pr__nfet_01v8 ad=2.86e+11p pd=3.24e+06u as=0p ps=0u w=550000u l=1.97e+06u
.ends

.subckt sky130_fd_sc_hd__a32o_1 VSUBS a_27_47# a_123_297# a_316_21# a_530_199# a_412_199#
+ w_n38_261# a_123_47# a_220_199# a_626_21#
X0 a_250_297# a_626_21# a_93_21# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=9.65e+11p pd=7.93e+06u as=2.8e+11p ps=2.56e+06u w=1e+06u l=150000u
X1 a_123_297# a_93_21# a_27_47# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=9.35e+11p pd=5.87e+06u as=3.3e+11p ps=2.66e+06u w=1e+06u l=150000u
X2 a_93_21# a_530_199# a_250_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X3 a_346_47# a_316_21# a_256_47# VSUBS sky130_fd_pr__nfet_01v8 ad=2.925e+11p pd=2.2e+06u as=1.95e+11p ps=1.9e+06u w=650000u l=150000u
X4 a_123_47# a_93_21# a_27_47# VSUBS sky130_fd_pr__nfet_01v8 ad=5.07e+11p pd=4.16e+06u as=2.145e+11p ps=1.96e+06u w=650000u l=150000u
X5 a_256_47# a_220_199# a_123_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X6 a_584_47# a_530_199# a_93_21# VSUBS sky130_fd_pr__nfet_01v8 ad=1.365e+11p pd=1.72e+06u as=2.86e+11p ps=2.18e+06u w=650000u l=150000u
X7 a_250_297# a_412_199# a_123_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X8 a_93_21# a_412_199# a_346_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X9 a_123_297# a_316_21# a_250_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X10 a_250_297# a_220_199# a_123_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X11 a_123_47# a_626_21# a_584_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__dfrtp_1 VSUBS a_1761_47# a_109_363# a_109_47# w_n38_261#
+ a_22_199# a_847_21# a_331_260#
X0 a_109_363# a_1283_21# a_1270_413# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=1.2195e+12p pd=1.255e+07u as=1.134e+11p ps=1.38e+06u w=420000u l=150000u
X1 a_761_289# a_543_47# a_109_363# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=2.583e+11p pd=2.37e+06u as=0p ps=0u w=840000u l=150000u
X2 a_761_289# a_543_47# a_109_47# VSUBS sky130_fd_pr__nfet_01v8 ad=1.998e+11p pd=1.97e+06u as=1.0617e+12p ps=9.62e+06u w=640000u l=150000u
X3 a_448_47# a_331_260# a_109_47# VSUBS sky130_fd_pr__nfet_01v8 ad=1.32e+11p pd=1.49e+06u as=0p ps=0u w=420000u l=150000u
X4 a_1270_413# a_193_47# a_1108_47# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=1.176e+11p ps=1.4e+06u w=420000u l=150000u
X5 a_1761_47# a_1283_21# a_109_47# VSUBS sky130_fd_pr__nfet_01v8 ad=1.69e+11p pd=1.82e+06u as=0p ps=0u w=650000u l=150000u
X6 a_109_47# a_1283_21# a_1217_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.338e+11p ps=1.5e+06u w=420000u l=150000u
X7 a_543_47# a_27_47# a_448_47# VSUBS sky130_fd_pr__nfet_01v8 ad=1.188e+11p pd=1.38e+06u as=0p ps=0u w=360000u l=150000u
X8 a_543_47# a_193_47# a_448_47# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=1.449e+11p pd=1.53e+06u as=1.302e+11p ps=1.46e+06u w=420000u l=150000u
X9 a_639_47# a_193_47# a_543_47# VSUBS sky130_fd_pr__nfet_01v8 ad=2.802e+11p pd=2.2e+06u as=0p ps=0u w=360000u l=150000u
X10 a_1217_47# a_27_47# a_1108_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.422e+11p ps=1.51e+06u w=360000u l=150000u
X11 a_1283_21# a_1108_47# a_1462_47# VSUBS sky130_fd_pr__nfet_01v8 ad=1.092e+11p pd=1.36e+06u as=1.281e+11p ps=1.45e+06u w=420000u l=150000u
X12 a_651_413# a_27_47# a_543_47# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=3.402e+11p pd=3.3e+06u as=0p ps=0u w=420000u l=150000u
X13 a_109_47# a_847_21# a_805_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=8.82e+10p ps=1.26e+06u w=420000u l=150000u
X14 a_1108_47# a_193_47# a_761_289# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=360000u l=150000u
X15 a_651_413# a_847_21# a_109_363# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X16 a_193_47# a_27_47# a_109_47# VSUBS sky130_fd_pr__nfet_01v8 ad=1.092e+11p pd=1.36e+06u as=0p ps=0u w=420000u l=150000u
X17 a_109_47# a_22_199# a_27_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.092e+11p ps=1.36e+06u w=420000u l=150000u
X18 a_109_363# a_22_199# a_27_47# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=1.664e+11p ps=1.8e+06u w=640000u l=150000u
X19 a_1761_47# a_1283_21# a_109_363# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=2.6e+11p pd=2.52e+06u as=0p ps=0u w=1e+06u l=150000u
X20 a_193_47# a_27_47# a_109_363# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=1.664e+11p pd=1.8e+06u as=0p ps=0u w=640000u l=150000u
X21 a_109_363# a_1108_47# a_1283_21# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=1.134e+11p ps=1.38e+06u w=420000u l=150000u
X22 a_1462_47# a_847_21# a_109_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X23 a_448_47# a_331_260# a_109_363# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X24 a_109_363# a_761_289# a_651_413# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X25 a_1108_47# a_27_47# a_761_289# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X26 a_1283_21# a_847_21# a_109_363# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X27 a_805_47# a_761_289# a_639_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
.ends

.subckt sky130_fd_sc_hd__clkbuf_2 VSUBS a_110_297# a_69_195# w_n38_261# a_205_47#
+ a_110_47#
X0 a_110_297# a_69_195# a_27_47# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=5.85e+11p pd=5.17e+06u as=2.65e+11p ps=2.53e+06u w=1e+06u l=150000u
X1 a_110_47# a_69_195# a_27_47# VSUBS sky130_fd_pr__nfet_01v8 ad=2.457e+11p pd=2.85e+06u as=1.113e+11p ps=1.37e+06u w=420000u l=150000u
X2 a_110_297# a_27_47# a_205_47# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.7e+11p ps=2.54e+06u w=1e+06u l=150000u
X3 a_205_47# a_27_47# a_110_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X4 a_110_47# a_27_47# a_205_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.134e+11p ps=1.38e+06u w=420000u l=150000u
X5 a_205_47# a_27_47# a_110_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
.ends

.subckt sky130_fd_sc_hd__or2_2 VSUBS a_27_47# a_294_47# w_n38_261# a_163_21# a_25_199#
+ a_193_297#
X0 a_121_297# a_25_199# a_39_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=8.82e+10p pd=1.26e+06u as=1.092e+11p ps=1.36e+06u w=420000u l=150000u
X1 a_193_297# a_39_297# a_294_47# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=5.715e+11p pd=5.23e+06u as=2.7e+11p ps=2.54e+06u w=1e+06u l=150000u
X2 a_294_47# a_39_297# a_27_47# VSUBS sky130_fd_pr__nfet_01v8 ad=1.755e+11p pd=1.84e+06u as=4.917e+11p ps=5.19e+06u w=650000u l=150000u
X3 a_294_47# a_39_297# a_193_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X4 a_27_47# a_163_21# a_39_297# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.134e+11p ps=1.38e+06u w=420000u l=150000u
X5 a_39_297# a_25_199# a_27_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X6 a_193_297# a_163_21# a_121_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X7 a_27_47# a_39_297# a_294_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__a21oi_1 VSUBS a_199_297# a_21_199# a_258_21# w_n38_261# a_30_297#
+ a_30_47# a_162_199#
X0 a_30_47# a_258_21# a_199_47# VSUBS sky130_fd_pr__nfet_01v8 ad=3.445e+11p pd=3.66e+06u as=1.9175e+11p ps=1.89e+06u w=650000u l=150000u
X1 a_199_297# a_162_199# a_113_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=2.95e+11p pd=2.59e+06u as=5.45e+11p ps=5.09e+06u w=1e+06u l=150000u
X2 a_113_297# a_21_199# a_30_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.65e+11p ps=2.53e+06u w=1e+06u l=150000u
X3 a_30_297# a_21_199# a_30_47# VSUBS sky130_fd_pr__nfet_01v8 ad=1.82e+11p pd=1.86e+06u as=0p ps=0u w=650000u l=150000u
X4 a_113_297# a_258_21# a_199_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X5 a_199_47# a_162_199# a_30_297# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__mux2_1 VSUBS a_27_47# a_109_297# a_109_47# w_n38_261# a_284_21#
+ a_291_329# a_172_199#
X0 a_218_374# a_172_199# a_109_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=1.533e+11p pd=1.57e+06u as=4.553e+11p ps=4.29e+06u w=420000u l=150000u
X1 a_439_47# a_291_329# a_76_199# VSUBS sky130_fd_pr__nfet_01v8 ad=1.386e+11p pd=1.5e+06u as=1.995e+11p ps=1.79e+06u w=420000u l=150000u
X2 a_109_297# a_505_21# a_535_374# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=8.82e+10p ps=1.26e+06u w=420000u l=150000u
X3 a_505_21# a_172_199# a_109_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=1.176e+11p pd=1.4e+06u as=0p ps=0u w=420000u l=150000u
X4 a_535_374# a_284_21# a_76_199# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=3.864e+11p ps=2.68e+06u w=420000u l=150000u
X5 a_76_199# a_284_21# a_218_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.386e+11p ps=1.5e+06u w=420000u l=150000u
X6 a_76_199# a_291_329# a_218_374# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X7 a_109_47# a_76_199# a_27_47# VSUBS sky130_fd_pr__nfet_01v8 ad=5.155e+11p pd=4.31e+06u as=1.69e+11p ps=1.82e+06u w=650000u l=150000u
X8 a_109_297# a_76_199# a_27_47# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.6e+11p ps=2.52e+06u w=1e+06u l=150000u
X9 a_218_47# a_172_199# a_109_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X10 a_505_21# a_172_199# a_109_47# VSUBS sky130_fd_pr__nfet_01v8 ad=1.092e+11p pd=1.36e+06u as=0p ps=0u w=420000u l=150000u
X11 a_109_47# a_505_21# a_439_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
.ends

.subckt sky130_fd_sc_hd__decap_12 VSUBS a_27_47# w_n38_261# a_27_323#
X0 a_27_323# a_27_47# a_27_323# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=4.524e+11p pd=4.52e+06u as=0p ps=0u w=870000u l=4.73e+06u
X1 a_27_47# a_27_323# a_27_47# VSUBS sky130_fd_pr__nfet_01v8 ad=2.86e+11p pd=3.24e+06u as=0p ps=0u w=550000u l=4.73e+06u
.ends

.subckt sky130_fd_sc_hd__o21ba_1 VSUBS a_125_47# a_586_199# a_109_297# a_27_297# w_n38_261#
+ a_192_67# a_490_199#
X0 a_125_47# a_490_199# a_448_47# VSUBS sky130_fd_pr__nfet_01v8 ad=3.76e+11p pd=3.81e+06u as=3.8675e+11p ps=3.79e+06u w=650000u l=150000u
X1 a_222_93# a_192_67# a_109_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=1.176e+11p pd=1.4e+06u as=9.515e+11p ps=7.99e+06u w=420000u l=150000u
X2 a_448_47# a_222_93# a_79_199# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.69e+11p ps=1.82e+06u w=650000u l=150000u
X3 a_222_93# a_192_67# a_125_47# VSUBS sky130_fd_pr__nfet_01v8 ad=1.092e+11p pd=1.36e+06u as=0p ps=0u w=420000u l=150000u
X4 a_448_47# a_586_199# a_125_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X5 a_109_297# a_586_199# a_544_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.1e+11p ps=2.42e+06u w=1e+06u l=150000u
X6 a_125_47# a_79_199# a_27_297# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.69e+11p ps=1.82e+06u w=650000u l=150000u
X7 a_109_297# a_79_199# a_27_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.6e+11p ps=2.52e+06u w=1e+06u l=150000u
X8 a_79_199# a_222_93# a_109_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=3.3e+11p pd=2.66e+06u as=0p ps=0u w=1e+06u l=150000u
X9 a_544_297# a_490_199# a_79_199# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
.ends

.subckt sky130_fd_sc_hd__buf_8 VSUBS a_361_47# a_28_203# a_109_297# a_109_47# w_n38_261#
X0 a_109_47# a_27_47# a_361_47# VSUBS sky130_fd_pr__nfet_01v8 ad=1.0465e+12p pd=1.102e+07u as=7.02e+11p ps=7.36e+06u w=650000u l=150000u
X1 a_109_47# a_27_47# a_361_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X2 a_109_297# a_27_47# a_361_47# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=1.61e+12p pd=1.522e+07u as=1.08e+12p ps=1.016e+07u w=1e+06u l=150000u
X3 a_361_47# a_27_47# a_109_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X4 a_361_47# a_27_47# a_109_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X5 a_361_47# a_27_47# a_109_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X6 a_361_47# a_27_47# a_109_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X7 a_109_47# a_27_47# a_361_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X8 a_109_297# a_27_47# a_361_47# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X9 a_109_297# a_27_47# a_361_47# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X10 a_361_47# a_27_47# a_109_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X11 a_361_47# a_27_47# a_109_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X12 a_109_47# a_27_47# a_361_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X13 a_109_47# a_28_203# a_27_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=3.445e+11p ps=3.66e+06u w=650000u l=150000u
X14 a_27_47# a_28_203# a_109_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X15 a_109_297# a_28_203# a_27_47# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=5.3e+11p ps=5.06e+06u w=1e+06u l=150000u
X16 a_109_47# a_28_203# a_27_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X17 a_109_297# a_27_47# a_361_47# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X18 a_109_297# a_28_203# a_27_47# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X19 a_27_47# a_28_203# a_109_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X20 a_361_47# a_27_47# a_109_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X21 a_361_47# a_27_47# a_109_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
.ends

.subckt sky130_fd_sc_hd__dfrtp_4 VSUBS a_109_363# a_109_47# w_n38_261# a_22_199# a_1741_47#
+ a_847_21# a_331_260#
X0 a_109_363# a_1283_21# a_1270_413# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=1.7533e+12p pd=1.756e+07u as=1.134e+11p ps=1.38e+06u w=420000u l=150000u
X1 a_761_289# a_543_47# a_109_363# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=2.583e+11p pd=2.37e+06u as=0p ps=0u w=840000u l=150000u
X2 a_761_289# a_543_47# a_109_47# VSUBS sky130_fd_pr__nfet_01v8 ad=1.998e+11p pd=1.97e+06u as=1.3795e+12p ps=1.312e+07u w=640000u l=150000u
X3 a_448_47# a_331_260# a_109_47# VSUBS sky130_fd_pr__nfet_01v8 ad=1.32e+11p pd=1.49e+06u as=0p ps=0u w=420000u l=150000u
X4 a_1270_413# a_193_47# a_1108_47# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=1.176e+11p ps=1.4e+06u w=420000u l=150000u
X5 a_1741_47# a_1283_21# a_109_363# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=5.4e+11p pd=5.08e+06u as=0p ps=0u w=1e+06u l=150000u
X6 a_109_47# a_1283_21# a_1217_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.338e+11p ps=1.5e+06u w=420000u l=150000u
X7 a_543_47# a_27_47# a_448_47# VSUBS sky130_fd_pr__nfet_01v8 ad=1.188e+11p pd=1.38e+06u as=0p ps=0u w=360000u l=150000u
X8 a_109_47# a_1283_21# a_1741_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=3.51e+11p ps=3.68e+06u w=650000u l=150000u
X9 a_543_47# a_193_47# a_448_47# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=1.449e+11p pd=1.53e+06u as=1.302e+11p ps=1.46e+06u w=420000u l=150000u
X10 a_639_47# a_193_47# a_543_47# VSUBS sky130_fd_pr__nfet_01v8 ad=2.802e+11p pd=2.2e+06u as=0p ps=0u w=360000u l=150000u
X11 a_1217_47# a_27_47# a_1108_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.422e+11p ps=1.51e+06u w=360000u l=150000u
X12 a_1283_21# a_1108_47# a_1462_47# VSUBS sky130_fd_pr__nfet_01v8 ad=1.092e+11p pd=1.36e+06u as=1.281e+11p ps=1.45e+06u w=420000u l=150000u
X13 a_1741_47# a_1283_21# a_109_363# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X14 a_1741_47# a_1283_21# a_109_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X15 a_651_413# a_27_47# a_543_47# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=3.402e+11p pd=3.3e+06u as=0p ps=0u w=420000u l=150000u
X16 a_109_47# a_847_21# a_805_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=8.82e+10p ps=1.26e+06u w=420000u l=150000u
X17 a_109_363# a_1283_21# a_1741_47# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X18 a_109_363# a_1283_21# a_1741_47# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X19 a_1108_47# a_193_47# a_761_289# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=360000u l=150000u
X20 a_651_413# a_847_21# a_109_363# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X21 a_193_47# a_27_47# a_109_47# VSUBS sky130_fd_pr__nfet_01v8 ad=1.092e+11p pd=1.36e+06u as=0p ps=0u w=420000u l=150000u
X22 a_109_47# a_22_199# a_27_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.092e+11p ps=1.36e+06u w=420000u l=150000u
X23 a_1741_47# a_1283_21# a_109_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X24 a_109_363# a_22_199# a_27_47# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=1.664e+11p ps=1.8e+06u w=640000u l=150000u
X25 a_193_47# a_27_47# a_109_363# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=1.664e+11p pd=1.8e+06u as=0p ps=0u w=640000u l=150000u
X26 a_109_363# a_1108_47# a_1283_21# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=1.134e+11p ps=1.38e+06u w=420000u l=150000u
X27 a_1462_47# a_847_21# a_109_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X28 a_448_47# a_331_260# a_109_363# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X29 a_109_47# a_1283_21# a_1741_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X30 a_109_363# a_761_289# a_651_413# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X31 a_1108_47# a_27_47# a_761_289# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X32 a_1283_21# a_847_21# a_109_363# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X33 a_805_47# a_761_289# a_639_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
.ends

.subckt sky130_fd_sc_hd__buf_1 VSUBS a_27_199# a_197_47# a_109_47# w_n38_261# a_109_339#
X0 a_197_47# a_27_47# a_109_47# VSUBS sky130_fd_pr__nfet_01v8 ad=1.352e+11p pd=1.56e+06u as=1.508e+11p ps=1.62e+06u w=520000u l=150000u
X1 a_109_339# a_27_199# a_27_47# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=2.291e+11p pd=2.16e+06u as=2.054e+11p ps=2.1e+06u w=790000u l=150000u
X2 a_109_47# a_27_199# a_27_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.352e+11p ps=1.56e+06u w=520000u l=150000u
X3 a_197_47# a_27_47# a_109_339# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=2.054e+11p pd=2.1e+06u as=0p ps=0u w=790000u l=150000u
.ends

.subckt sky130_fd_sc_hd__a31o_1 VSUBS a_465_21# a_27_47# a_110_297# a_177_199# a_273_21#
+ w_n38_261# a_369_21# a_110_47#
X0 a_110_47# a_465_21# a_80_21# VSUBS sky130_fd_pr__nfet_01v8 ad=4.3225e+11p pd=3.93e+06u as=2.145e+11p ps=1.96e+06u w=650000u l=150000u
X1 a_110_297# a_80_21# a_27_47# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=6.75e+11p pd=5.35e+06u as=2.65e+11p ps=2.53e+06u w=1e+06u l=150000u
X2 a_303_47# a_273_21# a_209_47# VSUBS sky130_fd_pr__nfet_01v8 ad=2.145e+11p pd=1.96e+06u as=2.08e+11p ps=1.94e+06u w=650000u l=150000u
X3 a_110_47# a_80_21# a_27_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.7225e+11p ps=1.83e+06u w=650000u l=150000u
X4 a_80_21# a_369_21# a_303_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X5 a_209_297# a_369_21# a_110_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=6.5e+11p pd=5.3e+06u as=0p ps=0u w=1e+06u l=150000u
X6 a_80_21# a_465_21# a_209_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=3.2e+11p pd=2.64e+06u as=0p ps=0u w=1e+06u l=150000u
X7 a_209_47# a_177_199# a_110_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X8 a_110_297# a_273_21# a_209_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X9 a_209_297# a_177_199# a_110_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
.ends

.subckt sky130_fd_sc_hd__dfrtp_2 VSUBS a_1761_47# a_109_363# a_109_47# w_n38_261#
+ a_22_199# a_847_21# a_331_260#
X0 a_109_363# a_1283_21# a_1270_413# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=1.4795e+12p pd=1.507e+07u as=1.134e+11p ps=1.38e+06u w=420000u l=150000u
X1 a_109_47# a_1283_21# a_1761_47# VSUBS sky130_fd_pr__nfet_01v8 ad=1.2307e+12p pd=1.144e+07u as=1.755e+11p ps=1.84e+06u w=650000u l=150000u
X2 a_761_289# a_543_47# a_109_363# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=2.583e+11p pd=2.37e+06u as=0p ps=0u w=840000u l=150000u
X3 a_761_289# a_543_47# a_109_47# VSUBS sky130_fd_pr__nfet_01v8 ad=1.998e+11p pd=1.97e+06u as=0p ps=0u w=640000u l=150000u
X4 a_448_47# a_331_260# a_109_47# VSUBS sky130_fd_pr__nfet_01v8 ad=1.32e+11p pd=1.49e+06u as=0p ps=0u w=420000u l=150000u
X5 a_1270_413# a_193_47# a_1108_47# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=1.176e+11p ps=1.4e+06u w=420000u l=150000u
X6 a_1761_47# a_1283_21# a_109_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X7 a_109_47# a_1283_21# a_1217_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.338e+11p ps=1.5e+06u w=420000u l=150000u
X8 a_543_47# a_27_47# a_448_47# VSUBS sky130_fd_pr__nfet_01v8 ad=1.188e+11p pd=1.38e+06u as=0p ps=0u w=360000u l=150000u
X9 a_543_47# a_193_47# a_448_47# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=1.449e+11p pd=1.53e+06u as=1.302e+11p ps=1.46e+06u w=420000u l=150000u
X10 a_639_47# a_193_47# a_543_47# VSUBS sky130_fd_pr__nfet_01v8 ad=2.802e+11p pd=2.2e+06u as=0p ps=0u w=360000u l=150000u
X11 a_1217_47# a_27_47# a_1108_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.422e+11p ps=1.51e+06u w=360000u l=150000u
X12 a_1283_21# a_1108_47# a_1462_47# VSUBS sky130_fd_pr__nfet_01v8 ad=1.092e+11p pd=1.36e+06u as=1.281e+11p ps=1.45e+06u w=420000u l=150000u
X13 a_651_413# a_27_47# a_543_47# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=3.402e+11p pd=3.3e+06u as=0p ps=0u w=420000u l=150000u
X14 a_109_47# a_847_21# a_805_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=8.82e+10p ps=1.26e+06u w=420000u l=150000u
X15 a_109_363# a_1283_21# a_1761_47# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.7e+11p ps=2.54e+06u w=1e+06u l=150000u
X16 a_1108_47# a_193_47# a_761_289# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=360000u l=150000u
X17 a_651_413# a_847_21# a_109_363# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X18 a_193_47# a_27_47# a_109_47# VSUBS sky130_fd_pr__nfet_01v8 ad=1.092e+11p pd=1.36e+06u as=0p ps=0u w=420000u l=150000u
X19 a_109_47# a_22_199# a_27_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.092e+11p ps=1.36e+06u w=420000u l=150000u
X20 a_109_363# a_22_199# a_27_47# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=1.664e+11p ps=1.8e+06u w=640000u l=150000u
X21 a_1761_47# a_1283_21# a_109_363# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X22 a_193_47# a_27_47# a_109_363# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=1.664e+11p pd=1.8e+06u as=0p ps=0u w=640000u l=150000u
X23 a_109_363# a_1108_47# a_1283_21# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=1.134e+11p ps=1.38e+06u w=420000u l=150000u
X24 a_1462_47# a_847_21# a_109_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X25 a_448_47# a_331_260# a_109_363# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X26 a_109_363# a_761_289# a_651_413# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X27 a_1108_47# a_27_47# a_761_289# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X28 a_1283_21# a_847_21# a_109_363# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X29 a_805_47# a_761_289# a_639_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
.ends

.subckt sky130_fd_sc_hd__or3_2 VSUBS a_280_297# a_24_199# a_235_199# a_378_47# w_n38_261#
+ a_112_53# a_148_429#
X0 a_378_47# a_30_53# a_280_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=2.7e+11p pd=2.54e+06u as=6.115e+11p ps=5.31e+06u w=1e+06u l=150000u
X1 a_184_297# a_148_429# a_112_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=1.386e+11p pd=1.5e+06u as=8.82e+10p ps=1.26e+06u w=420000u l=150000u
X2 a_280_297# a_235_199# a_184_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X3 a_280_297# a_30_53# a_378_47# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X4 a_112_53# a_235_199# a_30_53# VSUBS sky130_fd_pr__nfet_01v8 ad=5.024e+11p pd=5.23e+06u as=2.226e+11p ps=2.74e+06u w=420000u l=150000u
X5 a_112_297# a_24_199# a_30_53# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=1.092e+11p ps=1.36e+06u w=420000u l=150000u
X6 a_112_53# a_24_199# a_30_53# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X7 a_112_53# a_30_53# a_378_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.755e+11p ps=1.84e+06u w=650000u l=150000u
X8 a_30_53# a_148_429# a_112_53# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X9 a_378_47# a_30_53# a_112_53# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__o21a_1 VSUBS a_27_47# a_113_297# a_443_21# a_109_47# a_244_199#
+ w_n38_261# a_347_199#
X0 a_113_297# a_443_21# a_382_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=9.15e+11p pd=5.83e+06u as=3.05e+11p ps=2.61e+06u w=1e+06u l=150000u
X1 a_297_47# a_443_21# a_109_47# VSUBS sky130_fd_pr__nfet_01v8 ad=3.705e+11p pd=3.74e+06u as=3.445e+11p ps=3.66e+06u w=650000u l=150000u
X2 a_297_47# a_244_199# a_79_21# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.69e+11p ps=1.82e+06u w=650000u l=150000u
X3 a_113_297# a_79_21# a_27_47# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.8e+11p ps=2.56e+06u w=1e+06u l=150000u
X4 a_109_47# a_347_199# a_297_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X5 a_382_297# a_347_199# a_79_21# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=3.9e+11p ps=2.78e+06u w=1e+06u l=150000u
X6 a_79_21# a_244_199# a_113_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X7 a_109_47# a_79_21# a_27_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.69e+11p ps=1.82e+06u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__nor2_1 VSUBS a_27_47# a_181_297# a_27_297# w_n38_261# a_22_199#
+ a_151_235#
X0 a_181_297# a_151_235# a_109_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=2.6e+11p pd=2.52e+06u as=2.1e+11p ps=2.42e+06u w=1e+06u l=150000u
X1 a_27_47# a_151_235# a_27_297# VSUBS sky130_fd_pr__nfet_01v8 ad=3.38e+11p pd=3.64e+06u as=1.755e+11p ps=1.84e+06u w=650000u l=150000u
X2 a_27_297# a_22_199# a_27_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X3 a_109_297# a_22_199# a_27_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.6e+11p ps=2.52e+06u w=1e+06u l=150000u
.ends

.subckt sky130_fd_sc_hd__decap_3 VSUBS a_27_47# w_n38_261# a_27_323#
X0 a_27_323# a_27_47# a_27_323# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=4.524e+11p pd=4.52e+06u as=0p ps=0u w=870000u l=590000u
X1 a_27_47# a_27_323# a_27_47# VSUBS sky130_fd_pr__nfet_01v8 ad=2.86e+11p pd=3.24e+06u as=0p ps=0u w=550000u l=590000u
.ends

.subckt sky130_fd_sc_hd__a2bb2oi_1 VSUBS a_27_47# a_299_297# a_151_199# a_439_199#
+ a_27_297# w_n38_261# a_55_199# a_535_21#
X0 a_109_47# a_151_199# a_109_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=2.6e+11p pd=2.52e+06u as=2.1e+11p ps=2.42e+06u w=1e+06u l=150000u
X1 a_27_47# a_535_21# a_481_47# VSUBS sky130_fd_pr__nfet_01v8 ad=9.035e+11p pd=6.68e+06u as=1.755e+11p ps=1.84e+06u w=650000u l=150000u
X2 a_481_47# a_439_199# a_299_297# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.755e+11p ps=1.84e+06u w=650000u l=150000u
X3 a_397_297# a_109_47# a_299_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=5.3e+11p pd=5.06e+06u as=3.4e+11p ps=2.68e+06u w=1e+06u l=150000u
X4 a_397_297# a_535_21# a_27_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=5.3e+11p ps=5.06e+06u w=1e+06u l=150000u
X5 a_27_297# a_439_199# a_397_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X6 a_27_47# a_151_199# a_109_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.755e+11p ps=1.84e+06u w=650000u l=150000u
X7 a_109_47# a_55_199# a_27_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X8 a_109_297# a_55_199# a_27_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X9 a_299_297# a_109_47# a_27_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__clkbuf_1 VSUBS a_27_47# a_109_47# a_167_21# w_n38_261# a_109_339#
X0 a_75_212# a_167_21# a_109_47# VSUBS sky130_fd_pr__nfet_01v8 ad=1.352e+11p pd=1.56e+06u as=1.508e+11p ps=1.62e+06u w=520000u l=150000u
X1 a_109_339# a_75_212# a_27_47# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=2.291e+11p pd=2.16e+06u as=2.054e+11p ps=2.1e+06u w=790000u l=150000u
X2 a_109_47# a_75_212# a_27_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.352e+11p ps=1.56e+06u w=520000u l=150000u
X3 a_75_212# a_167_21# a_109_339# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=2.054e+11p pd=2.1e+06u as=0p ps=0u w=790000u l=150000u
.ends

.subckt sky130_fd_sc_hd__a22o_1 VSUBS a_27_47# a_417_192# a_155_21# w_n38_261# a_297_439#
+ a_565_47# a_55_199# a_299_199#
X0 a_297_439# a_417_192# a_109_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=5.629e+11p pd=5.14e+06u as=5.9e+11p ps=5.18e+06u w=1e+06u l=150000u
X1 a_109_297# a_299_199# a_297_439# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X2 a_27_47# a_417_192# a_373_47# VSUBS sky130_fd_pr__nfet_01v8 ad=3.705e+11p pd=3.74e+06u as=2.275e+11p ps=2e+06u w=650000u l=150000u
X3 a_27_297# a_155_21# a_109_47# VSUBS sky130_fd_pr__nfet_01v8 ad=3.38e+11p pd=3.64e+06u as=1.495e+11p ps=1.76e+06u w=650000u l=150000u
X4 a_565_47# a_27_297# a_27_47# VSUBS sky130_fd_pr__nfet_01v8 ad=1.69e+11p pd=1.82e+06u as=0p ps=0u w=650000u l=150000u
X5 a_373_47# a_299_199# a_27_297# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X6 a_565_47# a_27_297# a_297_439# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=2.6e+11p pd=2.52e+06u as=0p ps=0u w=1e+06u l=150000u
X7 a_109_47# a_55_199# a_27_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X8 a_109_297# a_55_199# a_27_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=5.1285e+11p ps=5.04e+06u w=1e+06u l=150000u
X9 a_27_297# a_155_21# a_109_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
.ends

.subckt sky130_fd_sc_hd__clkbuf_16 VSUBS a_27_47# a_454_47# a_27_297# w_n38_261# a_21_180#
X0 a_454_47# a_110_47# a_27_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=2.24e+12p pd=2.048e+07u as=3.045e+12p ps=2.809e+07u w=1e+06u l=150000u
X1 a_27_47# a_110_47# a_454_47# VSUBS sky130_fd_pr__nfet_01v8 ad=1.2789e+12p pd=1.533e+07u as=9.408e+11p ps=1.12e+07u w=420000u l=150000u
X2 a_27_47# a_110_47# a_454_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X3 a_27_297# a_21_180# a_110_47# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=5.6e+11p ps=5.12e+06u w=1e+06u l=150000u
X4 a_454_47# a_110_47# a_27_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X5 a_27_297# a_110_47# a_454_47# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X6 a_27_47# a_21_180# a_110_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=2.352e+11p ps=2.8e+06u w=420000u l=150000u
X7 a_110_47# a_21_180# a_27_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X8 a_454_47# a_110_47# a_27_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X9 a_110_47# a_21_180# a_27_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X10 a_27_47# a_110_47# a_454_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X11 a_27_47# a_110_47# a_454_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X12 a_27_297# a_21_180# a_110_47# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X13 a_454_47# a_110_47# a_27_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X14 a_27_47# a_110_47# a_454_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X15 a_110_47# a_21_180# a_27_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X16 a_454_47# a_110_47# a_27_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X17 a_27_47# a_110_47# a_454_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X18 a_454_47# a_110_47# a_27_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X19 a_454_47# a_110_47# a_27_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X20 a_27_297# a_110_47# a_454_47# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X21 a_27_297# a_110_47# a_454_47# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X22 a_27_297# a_110_47# a_454_47# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X23 a_454_47# a_110_47# a_27_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X24 a_454_47# a_110_47# a_27_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X25 a_454_47# a_110_47# a_27_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X26 a_27_297# a_110_47# a_454_47# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X27 a_27_47# a_110_47# a_454_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X28 a_454_47# a_110_47# a_27_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X29 a_454_47# a_110_47# a_27_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X30 a_27_47# a_110_47# a_454_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X31 a_27_297# a_110_47# a_454_47# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X32 a_27_297# a_110_47# a_454_47# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X33 a_27_297# a_110_47# a_454_47# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X34 a_27_47# a_21_180# a_110_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X35 a_454_47# a_110_47# a_27_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X36 a_110_47# a_21_180# a_27_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X37 a_454_47# a_110_47# a_27_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X38 a_454_47# a_110_47# a_27_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X39 a_454_47# a_110_47# a_27_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
.ends

.subckt sky130_fd_sc_hd__o221ai_4 VSUBS a_113_47# a_514_199# a_1199_199# a_1295_21#
+ a_775_21# a_27_297# w_n38_261# a_65_199# a_1241_47#
X0 a_553_297# a_775_21# a_113_47# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=1.08e+12p pd=1.016e+07u as=1.62e+12p ps=1.524e+07u w=1e+06u l=150000u
X1 a_27_47# a_65_199# a_113_47# VSUBS sky130_fd_pr__nfet_01v8 ad=1.2285e+12p pd=1.288e+07u as=3.51e+11p ps=3.68e+06u w=650000u l=150000u
X2 a_471_47# a_514_199# a_27_47# VSUBS sky130_fd_pr__nfet_01v8 ad=1.6185e+12p pd=1.668e+07u as=0p ps=0u w=650000u l=150000u
X3 a_471_47# a_1295_21# a_1241_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=7.02e+11p ps=7.36e+06u w=650000u l=150000u
X4 a_27_297# a_65_199# a_113_47# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=2.525e+12p pd=1.905e+07u as=0p ps=0u w=1e+06u l=150000u
X5 a_27_47# a_514_199# a_471_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X6 a_27_297# a_65_199# a_113_47# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X7 a_113_47# a_775_21# a_553_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X8 a_1241_297# a_1199_199# a_27_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=1.08e+12p pd=1.016e+07u as=0p ps=0u w=1e+06u l=150000u
X9 a_113_47# a_775_21# a_553_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X10 a_113_47# a_65_199# a_27_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X11 a_27_47# a_514_199# a_471_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X12 a_1241_47# a_1199_199# a_471_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X13 a_113_47# a_65_199# a_27_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X14 a_553_297# a_514_199# a_27_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X15 a_113_47# a_65_199# a_27_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X16 a_113_47# a_65_199# a_27_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X17 a_1241_297# a_1295_21# a_113_47# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X18 a_1241_297# a_1295_21# a_113_47# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X19 a_1241_47# a_1295_21# a_471_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X20 a_1241_47# a_1199_199# a_471_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X21 a_1241_297# a_1199_199# a_27_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X22 a_471_47# a_775_21# a_27_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X23 a_113_47# a_1295_21# a_1241_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X24 a_113_47# a_1295_21# a_1241_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X25 a_27_47# a_65_199# a_113_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X26 a_471_47# a_514_199# a_27_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X27 a_471_47# a_1295_21# a_1241_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X28 a_471_47# a_1199_199# a_1241_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X29 a_27_297# a_514_199# a_553_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X30 a_27_297# a_1199_199# a_1241_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X31 a_553_297# a_514_199# a_27_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X32 a_471_47# a_1199_199# a_1241_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X33 a_553_297# a_775_21# a_113_47# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X34 a_27_297# a_1199_199# a_1241_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X35 a_27_47# a_775_21# a_471_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X36 a_27_297# a_514_199# a_553_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X37 a_27_47# a_775_21# a_471_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X38 a_1241_47# a_1295_21# a_471_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X39 a_471_47# a_775_21# a_27_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__o21ai_1 VSUBS a_259_21# a_151_199# a_109_47# a_181_297# a_27_297#
+ w_n38_261# a_38_199#
X0 a_181_297# a_151_199# a_109_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=3.48e+11p pd=2.78e+06u as=2.1e+11p ps=2.42e+06u w=1e+06u l=150000u
X1 a_27_297# a_259_21# a_181_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=4.42e+11p pd=4.44e+06u as=0p ps=0u w=700000u l=150000u
X2 a_109_47# a_38_199# a_27_47# VSUBS sky130_fd_pr__nfet_01v8 ad=2.145e+11p pd=1.96e+06u as=3.445e+11p ps=3.66e+06u w=650000u l=150000u
X3 a_181_297# a_259_21# a_27_47# VSUBS sky130_fd_pr__nfet_01v8 ad=1.69e+11p pd=1.82e+06u as=0p ps=0u w=650000u l=150000u
X4 a_109_297# a_38_199# a_27_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X5 a_27_47# a_151_199# a_109_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__mux2_2 VSUBS a_449_185# a_27_47# a_633_21# a_109_47# a_27_297#
+ w_n38_261# a_353_21#
X0 a_288_47# a_257_199# a_27_47# VSUBS sky130_fd_pr__nfet_01v8 ad=1.365e+11p pd=1.49e+06u as=4.764e+11p ps=5.15e+06u w=420000u l=150000u
X1 a_79_21# a_449_185# a_306_369# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=2.624e+11p pd=2.1e+06u as=4.576e+11p ps=2.71e+06u w=640000u l=150000u
X2 a_79_21# a_353_21# a_288_47# VSUBS sky130_fd_pr__nfet_01v8 ad=3.465e+11p pd=2.49e+06u as=0p ps=0u w=420000u l=150000u
X3 a_578_47# a_449_185# a_79_21# VSUBS sky130_fd_pr__nfet_01v8 ad=1.155e+11p pd=1.39e+06u as=0p ps=0u w=420000u l=150000u
X4 a_257_199# a_633_21# a_27_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=1.728e+11p pd=1.82e+06u as=7.884e+11p ps=7.17e+06u w=640000u l=150000u
X5 a_591_369# a_353_21# a_79_21# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=1.344e+11p pd=1.7e+06u as=0p ps=0u w=640000u l=150000u
X6 a_257_199# a_633_21# a_27_47# VSUBS sky130_fd_pr__nfet_01v8 ad=1.134e+11p pd=1.38e+06u as=0p ps=0u w=420000u l=150000u
X7 a_27_297# a_633_21# a_591_369# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=640000u l=150000u
X8 a_27_47# a_633_21# a_578_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X9 a_27_47# a_79_21# a_109_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.755e+11p ps=1.84e+06u w=650000u l=150000u
X10 a_109_47# a_79_21# a_27_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X11 a_109_47# a_79_21# a_27_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=2.7e+11p pd=2.54e+06u as=0p ps=0u w=1e+06u l=150000u
X12 a_306_369# a_257_199# a_27_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=640000u l=150000u
X13 a_27_297# a_79_21# a_109_47# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
.ends

.subckt sky130_fd_sc_hd__o211a_1 VSUBS a_27_47# a_109_297# a_109_47# w_n38_261# a_266_199#
+ a_580_21# a_480_21# a_362_21#
X0 a_79_21# a_580_21# a_109_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=7.4e+11p pd=5.48e+06u as=8.7e+11p ps=7.74e+06u w=1e+06u l=150000u
X1 a_109_47# a_266_199# a_215_47# VSUBS sky130_fd_pr__nfet_01v8 ad=3.8025e+11p pd=3.77e+06u as=4.55e+11p ps=4e+06u w=650000u l=150000u
X2 a_510_47# a_480_21# a_215_47# VSUBS sky130_fd_pr__nfet_01v8 ad=2.275e+11p pd=2e+06u as=0p ps=0u w=650000u l=150000u
X3 a_79_21# a_362_21# a_297_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=3.25e+11p ps=2.65e+06u w=1e+06u l=150000u
X4 a_297_297# a_266_199# a_109_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X5 a_215_47# a_362_21# a_109_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X6 a_109_47# a_79_21# a_27_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.69e+11p ps=1.82e+06u w=650000u l=150000u
X7 a_109_297# a_79_21# a_27_47# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.6e+11p ps=2.52e+06u w=1e+06u l=150000u
X8 a_79_21# a_580_21# a_510_47# VSUBS sky130_fd_pr__nfet_01v8 ad=1.95e+11p pd=1.9e+06u as=0p ps=0u w=650000u l=150000u
X9 a_109_297# a_480_21# a_79_21# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
.ends

.subckt sky130_fd_sc_hd__o22a_1 VSUBS a_27_47# a_113_297# a_339_199# a_109_47# a_435_199#
+ w_n38_261# a_207_199# a_535_21#
X0 a_292_297# a_207_199# a_113_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=2.35e+11p pd=2.47e+06u as=1.005e+12p ps=6.01e+06u w=1e+06u l=150000u
X1 a_78_199# a_207_199# a_215_47# VSUBS sky130_fd_pr__nfet_01v8 ad=1.755e+11p pd=1.84e+06u as=5.655e+11p ps=5.64e+06u w=650000u l=150000u
X2 a_113_297# a_78_199# a_27_47# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.8e+11p ps=2.56e+06u w=1e+06u l=150000u
X3 a_78_199# a_339_199# a_292_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=4.7e+11p pd=2.94e+06u as=0p ps=0u w=1e+06u l=150000u
X4 a_215_47# a_535_21# a_109_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=3.445e+11p ps=3.66e+06u w=650000u l=150000u
X5 a_109_47# a_435_199# a_215_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X6 a_493_297# a_435_199# a_78_199# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=2.1e+11p pd=2.42e+06u as=0p ps=0u w=1e+06u l=150000u
X7 a_113_297# a_535_21# a_493_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X8 a_109_47# a_78_199# a_27_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.69e+11p ps=1.82e+06u w=650000u l=150000u
X9 a_215_47# a_339_199# a_78_199# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__o32a_1 VSUBS a_143_297# a_401_21# a_143_47# a_621_21# a_509_21#
+ w_n38_261# a_293_21# a_46_297# a_185_199#
X0 a_143_297# a_77_199# a_46_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=5.6e+11p pd=5.12e+06u as=3.35e+11p ps=2.67e+06u w=1e+06u l=150000u
X1 a_227_297# a_185_199# a_143_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=3.3e+11p pd=2.66e+06u as=0p ps=0u w=1e+06u l=150000u
X2 a_227_47# a_621_21# a_77_199# VSUBS sky130_fd_pr__nfet_01v8 ad=6.565e+11p pd=5.92e+06u as=2.665e+11p ps=2.12e+06u w=650000u l=150000u
X3 a_323_297# a_293_21# a_227_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=3.9e+11p pd=2.78e+06u as=0p ps=0u w=1e+06u l=150000u
X4 a_539_297# a_509_21# a_77_199# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=4.1e+11p pd=2.82e+06u as=3.9e+11p ps=2.78e+06u w=1e+06u l=150000u
X5 a_227_47# a_401_21# a_143_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=4.29e+11p ps=3.92e+06u w=650000u l=150000u
X6 a_143_47# a_77_199# a_46_297# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.69e+11p ps=1.82e+06u w=650000u l=150000u
X7 a_77_199# a_509_21# a_227_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X8 a_143_47# a_293_21# a_227_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X9 a_77_199# a_401_21# a_323_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X10 a_143_297# a_621_21# a_539_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X11 a_227_47# a_185_199# a_143_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__or3_1 VSUBS a_24_199# a_111_53# a_147_429# a_279_297# a_234_199#
+ w_n38_261# a_377_47#
X0 a_377_47# a_29_53# a_279_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=2.8e+11p pd=2.56e+06u as=2.965e+11p ps=2.68e+06u w=1e+06u l=150000u
X1 a_183_297# a_147_429# a_111_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=1.386e+11p pd=1.5e+06u as=8.82e+10p ps=1.26e+06u w=420000u l=150000u
X2 a_111_297# a_24_199# a_29_53# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=1.092e+11p ps=1.36e+06u w=420000u l=150000u
X3 a_377_47# a_29_53# a_111_53# VSUBS sky130_fd_pr__nfet_01v8 ad=1.82e+11p pd=1.86e+06u as=3.1715e+11p ps=3.36e+06u w=650000u l=150000u
X4 a_111_53# a_24_199# a_29_53# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=2.226e+11p ps=2.74e+06u w=420000u l=150000u
X5 a_111_53# a_234_199# a_29_53# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X6 a_279_297# a_234_199# a_183_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X7 a_29_53# a_147_429# a_111_53# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
.ends

.subckt sky130_fd_sc_hd__o221a_1 VSUBS a_554_199# a_191_199# a_149_297# a_430_47#
+ a_23_199# a_287_199# a_680_47# w_n38_261# a_438_199#
X0 a_512_297# a_438_199# a_51_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=2.1e+11p pd=2.42e+06u as=1.165e+12p ps=6.33e+06u w=1e+06u l=150000u
X1 a_149_297# a_554_199# a_512_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=6.6e+11p pd=5.32e+06u as=0p ps=0u w=1e+06u l=150000u
X2 a_680_47# a_51_297# a_149_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=2.8e+11p pd=2.56e+06u as=0p ps=0u w=1e+06u l=150000u
X3 a_680_47# a_51_297# a_430_47# VSUBS sky130_fd_pr__nfet_01v8 ad=1.82e+11p pd=1.86e+06u as=3.445e+11p ps=3.66e+06u w=650000u l=150000u
X4 a_240_47# a_191_199# a_149_47# VSUBS sky130_fd_pr__nfet_01v8 ad=3.51e+11p pd=3.68e+06u as=3.6725e+11p ps=3.73e+06u w=650000u l=150000u
X5 a_149_297# a_23_199# a_51_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X6 a_245_297# a_191_199# a_149_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=2.1e+11p pd=2.42e+06u as=0p ps=0u w=1e+06u l=150000u
X7 a_430_47# a_554_199# a_240_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X8 a_149_47# a_287_199# a_240_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X9 a_240_47# a_438_199# a_430_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X10 a_51_297# a_287_199# a_245_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X11 a_149_47# a_23_199# a_51_297# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=2.015e+11p ps=1.92e+06u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__and3_2 VSUBS a_265_53# a_154_27# w_n38_261# a_111_311# a_235_27#
+ a_386_47# a_28_199#
X0 a_265_53# a_29_311# a_386_47# VSUBS sky130_fd_pr__nfet_01v8 ad=4.3955e+11p pd=4.06e+06u as=1.755e+11p ps=1.84e+06u w=650000u l=150000u
X1 a_111_311# a_29_311# a_386_47# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=6.749e+11p pd=6.59e+06u as=2.7e+11p ps=2.54e+06u w=1e+06u l=150000u
X2 a_265_53# a_235_27# a_184_53# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.071e+11p ps=1.35e+06u w=420000u l=150000u
X3 a_111_311# a_28_199# a_29_311# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.5795e+11p ps=2.99e+06u w=420000u l=150000u
X4 a_386_47# a_29_311# a_265_53# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X5 a_184_53# a_154_27# a_112_53# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=8.82e+10p ps=1.26e+06u w=420000u l=150000u
X6 a_112_53# a_28_199# a_29_311# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.092e+11p ps=1.36e+06u w=420000u l=150000u
X7 a_386_47# a_29_311# a_111_311# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X8 a_29_311# a_154_27# a_111_311# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X9 a_111_311# a_235_27# a_29_311# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
.ends

.subckt sky130_fd_sc_hd__a221oi_2 VSUBS a_27_47# a_789_21# a_437_21# a_693_199# a_735_297#
+ a_111_47# w_n38_261# a_341_199# a_22_199#
X0 a_301_297# a_789_21# a_735_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=1.435e+12p pd=1.287e+07u as=5.4e+11p ps=5.08e+06u w=1e+06u l=150000u
X1 a_111_47# a_437_21# a_383_47# VSUBS sky130_fd_pr__nfet_01v8 ad=5.265e+11p pd=5.52e+06u as=3.51e+11p ps=3.68e+06u w=650000u l=150000u
X2 a_27_47# a_693_199# a_735_47# VSUBS sky130_fd_pr__nfet_01v8 ad=1.0855e+12p pd=8.54e+06u as=3.51e+11p ps=3.68e+06u w=650000u l=150000u
X3 a_301_297# a_693_199# a_735_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X4 a_27_47# a_22_199# a_111_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X5 a_111_47# a_22_199# a_27_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=2.7e+11p pd=2.54e+06u as=1.07e+12p ps=1.014e+07u w=1e+06u l=150000u
X6 a_735_47# a_789_21# a_111_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X7 a_735_297# a_789_21# a_301_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X8 a_383_47# a_341_199# a_27_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X9 a_735_47# a_693_199# a_27_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X10 a_301_297# a_437_21# a_27_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X11 a_301_297# a_341_199# a_27_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X12 a_27_297# a_341_199# a_301_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X13 a_27_297# a_437_21# a_301_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X14 a_111_47# a_789_21# a_735_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X15 a_27_47# a_341_199# a_383_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X16 a_735_297# a_693_199# a_301_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X17 a_383_47# a_437_21# a_111_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X18 a_111_47# a_22_199# a_27_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X19 a_27_297# a_22_199# a_111_47# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
.ends

.subckt sky130_fd_sc_hd__o2111a_1 VSUBS a_27_47# a_253_205# a_373_205# a_482_21# a_109_297#
+ a_109_47# a_718_21# w_n38_261# a_610_205#
X0 a_79_21# a_253_205# a_109_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=8.6e+11p pd=5.72e+06u as=1.64e+12p ps=9.28e+06u w=1e+06u l=150000u
X1 a_409_47# a_373_205# a_306_47# VSUBS sky130_fd_pr__nfet_01v8 ad=2.3725e+11p pd=2.03e+06u as=2.3725e+11p ps=2.03e+06u w=650000u l=150000u
X2 a_512_47# a_718_21# a_109_47# VSUBS sky130_fd_pr__nfet_01v8 ad=5.6875e+11p pd=4.35e+06u as=3.445e+11p ps=3.66e+06u w=650000u l=150000u
X3 a_306_47# a_253_205# a_79_21# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.9825e+11p ps=1.91e+06u w=650000u l=150000u
X4 a_109_47# a_610_205# a_512_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X5 a_79_21# a_482_21# a_109_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X6 a_109_297# a_373_205# a_79_21# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X7 a_676_297# a_610_205# a_79_21# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=2.1e+11p pd=2.42e+06u as=0p ps=0u w=1e+06u l=150000u
X8 a_109_297# a_718_21# a_676_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X9 a_512_47# a_482_21# a_409_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X10 a_109_47# a_79_21# a_27_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.69e+11p ps=1.82e+06u w=650000u l=150000u
X11 a_109_297# a_79_21# a_27_47# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.6e+11p ps=2.52e+06u w=1e+06u l=150000u
.ends

.subckt sky130_fd_sc_hd__nand2_1 VSUBS a_21_199# a_113_297# a_31_297# a_167_21# a_31_47#
+ w_n38_261#
X0 a_31_297# a_167_21# a_113_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=5.2e+11p pd=5.04e+06u as=2.7e+11p ps=2.54e+06u w=1e+06u l=150000u
X1 a_113_297# a_21_199# a_31_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X2 a_113_47# a_21_199# a_31_47# VSUBS sky130_fd_pr__nfet_01v8 ad=1.755e+11p pd=1.84e+06u as=1.69e+11p ps=1.82e+06u w=650000u l=150000u
X3 a_113_297# a_167_21# a_113_47# VSUBS sky130_fd_pr__nfet_01v8 ad=1.69e+11p pd=1.82e+06u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__and3_1 VSUBS a_381_47# w_n38_261# a_151_21# a_25_146# a_253_47#
+ a_109_300# a_223_21#
X0 a_253_47# a_223_21# a_181_47# VSUBS sky130_fd_pr__nfet_01v8 ad=2.633e+11p pd=2.28e+06u as=8.82e+10p ps=1.26e+06u w=420000u l=150000u
X1 a_109_300# a_25_146# a_27_47# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=3.9785e+11p pd=4.05e+06u as=2.415e+11p ps=2.83e+06u w=420000u l=150000u
X2 a_27_47# a_151_21# a_109_300# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X3 a_381_47# a_27_47# a_109_300# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=2.6e+11p pd=2.52e+06u as=0p ps=0u w=1e+06u l=150000u
X4 a_181_47# a_151_21# a_109_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=8.82e+10p ps=1.26e+06u w=420000u l=150000u
X5 a_109_47# a_25_146# a_27_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.092e+11p ps=1.36e+06u w=420000u l=150000u
X6 a_381_47# a_27_47# a_253_47# VSUBS sky130_fd_pr__nfet_01v8 ad=1.69e+11p pd=1.82e+06u as=0p ps=0u w=650000u l=150000u
X7 a_109_300# a_223_21# a_27_47# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
.ends

.subckt sky130_fd_sc_hd__o22ai_1 VSUBS a_21_199# a_349_199# a_297_47# a_154_199# a_109_47#
+ a_27_297# w_n38_261# a_253_199#
X0 a_307_297# a_253_199# a_109_47# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=2.1e+11p pd=2.42e+06u as=4.65e+11p ps=2.93e+06u w=1e+06u l=150000u
X1 a_27_297# a_349_199# a_307_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=5.3e+11p pd=5.06e+06u as=0p ps=0u w=1e+06u l=150000u
X2 a_109_47# a_154_199# a_109_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.25e+11p ps=2.45e+06u w=1e+06u l=150000u
X3 a_297_47# a_253_199# a_27_47# VSUBS sky130_fd_pr__nfet_01v8 ad=1.755e+11p pd=1.84e+06u as=5.6875e+11p ps=5.65e+06u w=650000u l=150000u
X4 a_109_47# a_21_199# a_27_47# VSUBS sky130_fd_pr__nfet_01v8 ad=1.8525e+11p pd=1.87e+06u as=0p ps=0u w=650000u l=150000u
X5 a_27_47# a_154_199# a_109_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X6 a_109_297# a_21_199# a_27_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X7 a_27_47# a_349_199# a_297_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__or3_4 VSUBS a_247_21# a_467_47# a_151_199# a_109_47# w_n38_261#
+ a_25_199# a_277_297#
X0 a_467_47# a_27_47# a_109_47# VSUBS sky130_fd_pr__nfet_01v8 ad=3.51e+11p pd=3.68e+06u as=1.07575e+12p ps=8.51e+06u w=650000u l=150000u
X1 a_467_47# a_27_47# a_277_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=5.4e+11p pd=5.08e+06u as=1.43e+12p ps=8.86e+06u w=1e+06u l=150000u
X2 a_467_47# a_27_47# a_277_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X3 a_109_47# a_247_21# a_27_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=3.445e+11p ps=3.66e+06u w=650000u l=150000u
X4 a_277_297# a_27_47# a_467_47# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X5 a_467_47# a_27_47# a_109_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X6 a_27_47# a_151_199# a_109_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X7 a_277_297# a_247_21# a_193_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.7e+11p ps=2.54e+06u w=1e+06u l=150000u
X8 a_109_47# a_25_199# a_27_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X9 a_109_47# a_27_47# a_467_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X10 a_109_297# a_25_199# a_27_47# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=2.7e+11p pd=2.54e+06u as=2.6e+11p ps=2.52e+06u w=1e+06u l=150000u
X11 a_277_297# a_27_47# a_467_47# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X12 a_193_297# a_151_199# a_109_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X13 a_109_47# a_27_47# a_467_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__or2_1 VSUBS a_192_21# a_319_47# a_50_199# a_56_47# a_222_297#
+ w_n38_261#
X0 a_222_297# a_192_21# a_150_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=2.915e+11p pd=2.67e+06u as=8.82e+10p ps=1.26e+06u w=420000u l=150000u
X1 a_319_47# a_68_297# a_56_47# VSUBS sky130_fd_pr__nfet_01v8 ad=1.69e+11p pd=1.82e+06u as=3.097e+11p ps=3.33e+06u w=650000u l=150000u
X2 a_68_297# a_50_199# a_56_47# VSUBS sky130_fd_pr__nfet_01v8 ad=1.134e+11p pd=1.38e+06u as=0p ps=0u w=420000u l=150000u
X3 a_56_47# a_192_21# a_68_297# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X4 a_150_297# a_50_199# a_68_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=1.092e+11p ps=1.36e+06u w=420000u l=150000u
X5 a_319_47# a_68_297# a_222_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=3.4e+11p pd=2.68e+06u as=0p ps=0u w=1e+06u l=150000u
.ends

.subckt sky130_fd_sc_hd__a2bb2o_1 VSUBS a_610_21# a_27_47# a_109_297# a_109_47# a_268_242#
+ w_n38_261# a_172_199# a_526_21#
X0 a_109_297# a_526_21# a_489_413# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=4.469e+11p pd=4.25e+06u as=2.226e+11p ps=2.74e+06u w=420000u l=150000u
X1 a_226_47# a_172_199# a_109_47# VSUBS sky130_fd_pr__nfet_01v8 ad=1.134e+11p pd=1.38e+06u as=6.266e+11p ps=5.69e+06u w=420000u l=150000u
X2 a_556_47# a_526_21# a_76_199# VSUBS sky130_fd_pr__nfet_01v8 ad=1.134e+11p pd=1.38e+06u as=1.134e+11p ps=1.38e+06u w=420000u l=150000u
X3 a_226_297# a_172_199# a_109_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=8.82e+10p pd=1.26e+06u as=0p ps=0u w=420000u l=150000u
X4 a_226_47# a_268_242# a_226_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=1.113e+11p pd=1.37e+06u as=0p ps=0u w=420000u l=150000u
X5 a_76_199# a_226_47# a_109_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X6 a_109_47# a_76_199# a_27_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.69e+11p ps=1.82e+06u w=650000u l=150000u
X7 a_109_297# a_76_199# a_27_47# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.6e+11p ps=2.52e+06u w=1e+06u l=150000u
X8 a_489_413# a_226_47# a_76_199# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=1.092e+11p ps=1.36e+06u w=420000u l=150000u
X9 a_109_47# a_268_242# a_226_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X10 a_489_413# a_610_21# a_109_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X11 a_109_47# a_610_21# a_556_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
.ends

.subckt sky130_fd_sc_hd__nor2_2 VSUBS a_113_47# a_27_47# a_113_297# a_251_21# a_83_21#
+ w_n38_261#
X0 a_27_47# a_251_21# a_113_47# VSUBS sky130_fd_pr__nfet_01v8 ad=5.265e+11p pd=5.52e+06u as=3.51e+11p ps=3.68e+06u w=650000u l=150000u
X1 a_27_297# a_83_21# a_113_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=8.1e+11p pd=7.62e+06u as=2.7e+11p ps=2.54e+06u w=1e+06u l=150000u
X2 a_27_297# a_251_21# a_113_47# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.7e+11p ps=2.54e+06u w=1e+06u l=150000u
X3 a_113_47# a_251_21# a_27_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X4 a_113_47# a_251_21# a_27_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X5 a_113_297# a_83_21# a_27_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X6 a_113_47# a_83_21# a_27_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X7 a_27_47# a_83_21# a_113_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__and2_1 VSUBS a_337_47# a_229_75# a_59_371# w_n38_261# a_199_49#
+ a_58_199#
X0 a_337_47# a_59_75# a_229_75# VSUBS sky130_fd_pr__nfet_01v8 ad=1.82e+11p pd=1.86e+06u as=2.236e+11p ps=2.08e+06u w=650000u l=150000u
X1 a_59_75# a_58_199# a_59_371# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=1.134e+11p pd=1.38e+06u as=4.507e+11p ps=4.18e+06u w=420000u l=150000u
X2 a_145_75# a_58_199# a_59_75# VSUBS sky130_fd_pr__nfet_01v8 ad=1.134e+11p pd=1.38e+06u as=1.176e+11p ps=1.4e+06u w=420000u l=150000u
X3 a_59_371# a_199_49# a_59_75# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X4 a_229_75# a_199_49# a_145_75# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X5 a_337_47# a_59_75# a_59_371# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=4.75e+11p pd=2.95e+06u as=0p ps=0u w=1e+06u l=150000u
.ends

.subckt sky130_fd_sc_hd__or4b_4 VSUBS a_349_199# a_27_93# a_445_199# w_n38_261# a_27_413#
+ a_677_47# a_45_199# a_541_21#
X0 a_487_297# a_445_199# a_403_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=2.7e+11p pd=2.54e+06u as=2.7e+11p ps=2.54e+06u w=1e+06u l=150000u
X1 a_27_413# a_215_297# a_677_47# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=1.0192e+12p pd=9.18e+06u as=5.4e+11p ps=5.08e+06u w=1e+06u l=150000u
X2 a_27_93# a_215_297# a_677_47# VSUBS sky130_fd_pr__nfet_01v8 ad=1.0513e+12p pd=1.077e+07u as=3.51e+11p ps=3.68e+06u w=650000u l=150000u
X3 a_403_297# a_349_199# a_297_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=3.8e+11p ps=2.76e+06u w=1e+06u l=150000u
X4 a_27_413# a_541_21# a_487_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X5 a_215_297# a_109_93# a_27_93# VSUBS sky130_fd_pr__nfet_01v8 ad=4.225e+11p pd=3.9e+06u as=0p ps=0u w=650000u l=150000u
X6 a_677_47# a_215_297# a_27_93# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X7 a_297_297# a_109_93# a_215_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.6e+11p ps=2.52e+06u w=1e+06u l=150000u
X8 a_27_93# a_541_21# a_215_297# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X9 a_109_93# a_45_199# a_27_93# VSUBS sky130_fd_pr__nfet_01v8 ad=1.0785e+11p pd=1.36e+06u as=0p ps=0u w=420000u l=150000u
X10 a_109_93# a_45_199# a_27_413# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=1.092e+11p pd=1.36e+06u as=0p ps=0u w=420000u l=150000u
X11 a_677_47# a_215_297# a_27_413# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X12 a_677_47# a_215_297# a_27_413# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X13 a_215_297# a_445_199# a_27_93# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X14 a_677_47# a_215_297# a_27_93# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X15 a_27_413# a_215_297# a_677_47# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X16 a_27_93# a_349_199# a_215_297# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X17 a_27_93# a_215_297# a_677_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__a31oi_2 VSUBS a_467_47# a_235_199# a_403_199# a_109_297#
+ a_109_47# w_n38_261# a_711_21# a_22_199#
X0 a_27_47# a_235_199# a_277_47# VSUBS sky130_fd_pr__nfet_01v8 ad=5.135e+11p pd=5.48e+06u as=3.705e+11p ps=3.74e+06u w=650000u l=150000u
X1 a_467_47# a_711_21# a_27_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=3.5e+11p pd=2.7e+06u as=1.42e+12p ps=1.284e+07u w=1e+06u l=150000u
X2 a_109_47# a_711_21# a_467_47# VSUBS sky130_fd_pr__nfet_01v8 ad=4.03e+11p pd=3.84e+06u as=5.72e+11p ps=5.66e+06u w=650000u l=150000u
X3 a_467_47# a_403_199# a_277_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X4 a_27_297# a_711_21# a_467_47# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X5 a_277_47# a_235_199# a_27_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X6 a_277_47# a_403_199# a_467_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X7 a_27_297# a_403_199# a_109_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=1.36e+12p ps=8.72e+06u w=1e+06u l=150000u
X8 a_27_47# a_22_199# a_109_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X9 a_109_297# a_235_199# a_27_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X10 a_109_47# a_22_199# a_27_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X11 a_109_297# a_403_199# a_27_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X12 a_109_297# a_22_199# a_27_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X13 a_27_297# a_22_199# a_109_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X14 a_27_297# a_235_199# a_109_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X15 a_467_47# a_711_21# a_109_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__o221ai_1 VSUBS a_27_47# a_343_199# a_113_297# a_481_47# a_439_199#
+ a_49_199# w_n38_261# a_227_199# a_535_21#
X0 a_295_297# a_227_199# a_113_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=2.4e+11p pd=2.48e+06u as=1.02e+12p ps=6.04e+06u w=1e+06u l=150000u
X1 a_113_297# a_49_199# a_27_47# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=7.3e+11p ps=5.46e+06u w=1e+06u l=150000u
X2 a_213_123# a_535_21# a_481_47# VSUBS sky130_fd_pr__nfet_01v8 ad=5.682e+11p pd=5.66e+06u as=1.755e+11p ps=1.84e+06u w=650000u l=150000u
X3 a_481_47# a_439_199# a_213_123# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X4 a_493_297# a_439_199# a_27_47# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=2.1e+11p pd=2.42e+06u as=0p ps=0u w=1e+06u l=150000u
X5 a_113_297# a_535_21# a_493_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X6 a_213_123# a_343_199# a_109_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=3.409e+11p ps=3.66e+06u w=650000u l=150000u
X7 a_109_47# a_49_199# a_27_47# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.69e+11p ps=1.82e+06u w=650000u l=150000u
X8 a_27_47# a_343_199# a_295_297# w_n38_261# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X9 a_109_47# a_227_199# a_213_123# VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sarlogic VSUBS li_8953_12869# li_765_8857# li_15117_3961# li_15117_11033#
+ li_15117_9945# m1_92_1040# li_765_11237# li_397_9469# li_3249_697# m1_92_496# li_15117_9537#
+ li_6929_12869# li_489_7769# li_15025_12937# li_857_2397# li_489_11781# li_765_6681#
+ li_15025_629# li_673_4505# li_1777_12937# li_14381_12869# li_489_10489# li_14381_697#
+ li_15117_8857# li_1501_2397# li_15117_2601# li_11253_697# li_6745_765# li_4905_12937#
+ li_3249_12869# li_15025_5525# li_11161_1241# li_11253_12869# li_12909_629# li_12909_12937#
+ li_397_833# li_15117_12121# li_7113_1241# li_15117_1785# li_949_1241# li_765_5593#
+ li_949_12869# li_15117_3417# li_6653_7361#
XFILLER_22_100 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_13_111 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_8
XFILLER_13_144 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_13_155 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
X_294_ VSUBS m1_92_496# li_11437_5253# m1_92_1040# li_14933_6409# m1_92_496# sky130_fd_sc_hd__inv_2
X_346_ VSUBS li_7297_12121# li_10885_8925# li_11433_7769# m1_92_496# m1_92_1040# li_7573_11713#
+ m1_92_496# sky130_fd_sc_hd__dfstp_1
XFILLER_12_65 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_6
X_277_ VSUBS m1_92_496# li_6285_12733# m1_92_1040# li_11161_1717# m1_92_496# sky130_fd_sc_hd__inv_2
X_200_ VSUBS li_10609_2465# m1_92_496# li_6837_2397# li_9137_2601# li_10701_1173#
+ m1_92_496# m1_92_1040# li_9321_833# li_8677_2533# sky130_fd_sc_hd__a32o_1
X_329_ VSUBS li_6929_11169# m1_92_496# m1_92_1040# m1_92_496# li_7573_11713# li_7297_12121#
+ li_7573_11305# sky130_fd_sc_hd__dfrtp_1
XFILLER_2_110 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_2_154 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_6
XFILLER_0_68 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_9_11 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_8
XFILLER_18_42 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_18_53 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_20_32 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_8
XFILLER_15_87 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
Xoutput20 VSUBS m1_92_496# li_11529_11781# m1_92_496# li_12909_12937# m1_92_1040#
+ sky130_fd_sc_hd__clkbuf_2
XFILLER_16_164 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
Xoutput31 VSUBS m1_92_496# li_14381_10013# m1_92_496# li_15117_3417# m1_92_1040# sky130_fd_sc_hd__clkbuf_2
Xoutput7 VSUBS m1_92_496# li_2237_901# m1_92_496# li_3249_697# m1_92_1040# sky130_fd_sc_hd__clkbuf_2
XFILLER_22_156 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
X_293_ VSUBS m1_92_1040# li_11437_5253# m1_92_496# li_9505_901# li_9781_5253# m1_92_496#
+ sky130_fd_sc_hd__or2_2
XFILLER_10_115 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
X_345_ VSUBS li_7297_12121# li_12817_8041# li_12173_7769# m1_92_496# m1_92_1040# li_7573_11713#
+ m1_92_496# sky130_fd_sc_hd__dfstp_1
X_276_ VSUBS m1_92_1040# li_6285_12733# m1_92_496# li_3801_11101# li_673_10693# m1_92_496#
+ sky130_fd_sc_hd__or2_2
X_328_ VSUBS li_3801_11101# m1_92_496# m1_92_1040# m1_92_496# li_7573_11713# li_1225_901#
+ li_7297_11645# sky130_fd_sc_hd__dfrtp_1
XFILLER_2_122 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
X_259_ VSUBS m1_92_496# li_13737_2397# li_8953_5049# m1_92_496# li_12081_3485# m1_92_1040#
+ li_9735_3417# sky130_fd_sc_hd__a21oi_1
XFILLER_0_25 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_9_56 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_18_32 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_6_68 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_15_11 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_8
Xoutput21 VSUBS m1_92_496# li_4353_11781# m1_92_496# li_15025_12937# m1_92_1040# sky130_fd_sc_hd__clkbuf_2
Xoutput10 VSUBS m1_92_496# li_11161_1717# m1_92_496# li_11253_697# m1_92_1040# sky130_fd_sc_hd__clkbuf_2
Xoutput32 VSUBS m1_92_496# li_14289_4709# m1_92_496# li_15117_3961# m1_92_1040# sky130_fd_sc_hd__clkbuf_2
Xoutput8 VSUBS m1_92_496# li_6929_901# m1_92_496# li_6745_765# m1_92_1040# sky130_fd_sc_hd__clkbuf_2
XFILLER_22_146 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_6
X_292_ VSUBS m1_92_496# li_14105_3621# m1_92_1040# li_14197_12801# m1_92_496# sky130_fd_sc_hd__inv_2
XFILLER_9_139 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_3_69 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_3_25 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_6_109 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_10_149 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
X_344_ VSUBS li_7297_12121# li_13001_7293# li_12817_6273# m1_92_496# m1_92_1040# li_7573_11713#
+ m1_92_496# sky130_fd_sc_hd__dfstp_1
X_275_ VSUBS m1_92_496# li_3893_10557# m1_92_1040# li_7297_1241# m1_92_496# sky130_fd_sc_hd__inv_2
XFILLER_5_164 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_5_153 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_6
XFILLER_5_131 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_0_59 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_3_3 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_0_15 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_6
X_327_ VSUBS li_2237_11033# m1_92_496# m1_92_1040# m1_92_496# li_581_12189# li_1225_901#
+ li_5365_12053# sky130_fd_sc_hd__dfrtp_1
X_258_ VSUBS li_9413_5321# m1_92_496# m1_92_1040# m1_92_496# li_9873_5117# li_9781_5253#
+ li_8953_5049# sky130_fd_sc_hd__mux2_1
X_189_ VSUBS m1_92_496# li_4721_4097# m1_92_496# li_4905_1921# m1_92_1040# sky130_fd_sc_hd__clkbuf_2
XFILLER_18_88 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_1_80 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_6
XFILLER_6_58 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
Xoutput22 VSUBS m1_92_496# li_489_7497# m1_92_496# li_765_6681# m1_92_1040# sky130_fd_sc_hd__clkbuf_2
Xoutput11 VSUBS m1_92_496# li_11161_10421# m1_92_496# li_11161_1241# m1_92_1040# sky130_fd_sc_hd__clkbuf_2
Xoutput33 VSUBS m1_92_496# li_14473_11713# m1_92_496# li_15117_1785# m1_92_1040# sky130_fd_sc_hd__clkbuf_2
Xoutput9 VSUBS m1_92_496# li_7297_1241# m1_92_496# li_7113_1241# m1_92_1040# sky130_fd_sc_hd__clkbuf_2
XFILLER_22_125 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_12
XFILLER_9_129 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_6
X_291_ VSUBS m1_92_1040# li_14105_3621# m1_92_496# li_9735_3417# li_13737_2397# m1_92_496#
+ sky130_fd_sc_hd__or2_2
XFILLER_12_24 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_8
X_274_ VSUBS m1_92_1040# li_3893_10557# m1_92_496# li_2237_11033# li_581_9605# m1_92_496#
+ sky130_fd_sc_hd__or2_2
X_343_ VSUBS li_2329_3553# m1_92_496# m1_92_1040# m1_92_496# li_581_3553# li_1225_901#
+ li_857_3417# sky130_fd_sc_hd__dfrtp_1
XFILLER_0_38 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_8
X_326_ VSUBS li_2145_8789# m1_92_496# m1_92_1040# m1_92_496# li_581_12189# li_1225_901#
+ li_5825_9673# sky130_fd_sc_hd__dfrtp_1
X_257_ VSUBS m1_92_1040# li_4905_1921# m1_92_496# li_8953_5049# m1_92_496# li_7573_5117#
+ li_8493_5185# sky130_fd_sc_hd__o21ba_1
XFILLER_9_25 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_9_69 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
X_188_ VSUBS li_2789_6341# m1_92_496# m1_92_1040# m1_92_496# li_581_2805# li_3893_6273#
+ li_3893_5661# sky130_fd_sc_hd__mux2_1
X_309_ VSUBS li_14289_5117# m1_92_496# m1_92_1040# m1_92_496# li_6653_1377# li_7297_12121#
+ li_12725_5525# sky130_fd_sc_hd__dfrtp_1
XFILLER_19_164 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_10_90 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
Xoutput23 VSUBS m1_92_496# li_673_7769# m1_92_496# li_489_7769# m1_92_1040# sky130_fd_sc_hd__clkbuf_2
Xoutput12 VSUBS m1_92_496# li_12633_11033# m1_92_496# li_12909_629# m1_92_1040# sky130_fd_sc_hd__clkbuf_2
Xoutput34 VSUBS m1_92_496# li_14105_3621# m1_92_496# li_14381_697# m1_92_1040# sky130_fd_sc_hd__clkbuf_2
XFILLER_11_3 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
X_290_ VSUBS m1_92_496# li_14473_11713# m1_92_1040# li_14381_11849# m1_92_496# sky130_fd_sc_hd__inv_2
Xrepeater42 VSUBS li_7297_12121# li_1225_901# m1_92_496# m1_92_1040# m1_92_496# sky130_fd_sc_hd__buf_8
XFILLER_9_119 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_6
XFILLER_10_129 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_6
XFILLER_12_58 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_5_144 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_5_122 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_6
X_273_ VSUBS m1_92_496# li_3893_8857# m1_92_1040# li_6929_901# m1_92_496# sky130_fd_sc_hd__inv_2
X_342_ VSUBS m1_92_496# m1_92_1040# m1_92_496# li_581_3553# li_2973_5117# li_1225_901#
+ li_1225_5253# sky130_fd_sc_hd__dfrtp_4
X_325_ VSUBS li_2145_7701# m1_92_496# m1_92_1040# m1_92_496# li_581_12189# li_1225_901#
+ li_6469_8993# sky130_fd_sc_hd__dfrtp_1
X_187_ VSUBS li_397_3009# li_581_2805# m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__buf_1
X_256_ VSUBS li_2329_2601# li_7573_5117# m1_92_496# li_6193_3961# li_2329_2397# m1_92_496#
+ li_4721_4097# m1_92_1040# sky130_fd_sc_hd__a31o_1
X_239_ VSUBS m1_92_496# li_673_10693# li_2329_11101# m1_92_496# li_3985_11305# m1_92_1040#
+ li_3801_11101# sky130_fd_sc_hd__a21oi_1
X_308_ VSUBS li_3985_5661# m1_92_496# m1_92_1040# m1_92_496# li_949_2261# li_2329_2601#
+ li_5641_4641# sky130_fd_sc_hd__mux2_1
XFILLER_20_47 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_8
XFILLER_20_58 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_20_8 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
Xoutput24 VSUBS m1_92_496# li_949_8857# m1_92_496# li_765_8857# m1_92_1040# sky130_fd_sc_hd__clkbuf_2
XFILLER_15_25 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
Xoutput13 VSUBS m1_92_496# li_14289_11033# m1_92_496# li_15025_629# m1_92_1040# sky130_fd_sc_hd__clkbuf_2
Xoutput35 VSUBS m1_92_496# li_11437_5253# m1_92_496# li_15025_5525# m1_92_1040# sky130_fd_sc_hd__clkbuf_2
XFILLER_16_135 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_12
XFILLER_16_157 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_13_127 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_8_164 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_8_131 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_12_37 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
X_272_ VSUBS m1_92_1040# li_3893_8857# m1_92_496# li_2145_8789# li_949_8857# m1_92_496#
+ sky130_fd_sc_hd__or2_2
X_341_ VSUBS m1_92_496# m1_92_1040# m1_92_496# li_581_3553# li_397_3009# li_1225_901#
+ li_2789_6341# sky130_fd_sc_hd__dfrtp_4
X_324_ VSUBS li_1409_7769# m1_92_496# m1_92_1040# m1_92_496# li_581_12189# li_1225_901#
+ li_5825_6409# sky130_fd_sc_hd__dfrtp_2
XFILLER_2_115 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
X_255_ VSUBS m1_92_496# li_2605_3145# li_2973_5117# li_6193_3961# m1_92_496# m1_92_1040#
+ li_581_2805# sky130_fd_sc_hd__or3_2
X_186_ VSUBS li_1225_5253# m1_92_496# li_3985_5661# m1_92_1040# li_3709_5661# m1_92_496#
+ li_3893_5661# sky130_fd_sc_hd__o21a_1
XFILLER_18_58 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_8
XFILLER_1_3 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_6
X_238_ VSUBS m1_92_1040# m1_92_496# li_9413_11033# m1_92_496# li_8769_12393# li_765_10013#
+ sky130_fd_sc_hd__nor2_1
X_169_ VSUBS m1_92_1040# m1_92_496# li_11437_8449# m1_92_496# li_11713_6273# li_3709_5661#
+ sky130_fd_sc_hd__nor2_1
XFILLER_1_72 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
X_307_ VSUBS li_3893_6273# m1_92_496# m1_92_1040# m1_92_496# li_4813_8449# li_6009_5661#
+ li_5641_4641# sky130_fd_sc_hd__mux2_1
XFILLER_19_144 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_8
XFILLER_13_8 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_6_28 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_8
XFILLER_10_81 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_10_70 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
Xoutput36 VSUBS m1_92_496# li_14289_10217# m1_92_496# li_15117_11033# m1_92_1040#
+ sky130_fd_sc_hd__clkbuf_2
XFILLER_16_147 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_6
Xoutput14 VSUBS m1_92_496# li_1133_12801# m1_92_496# li_949_12869# m1_92_1040# sky130_fd_sc_hd__clkbuf_2
Xoutput25 VSUBS m1_92_496# li_581_9605# m1_92_496# li_397_9469# m1_92_1040# sky130_fd_sc_hd__clkbuf_2
XFILLER_22_117 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XPHY_0 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_3
XFILLER_13_139 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_3_18 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_8_110 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
X_340_ VSUBS li_9505_901# m1_92_496# m1_92_1040# m1_92_496# li_6653_1377# li_7297_12121#
+ li_8677_2941# sky130_fd_sc_hd__dfrtp_1
X_271_ VSUBS m1_92_496# li_2329_833# m1_92_1040# li_2237_901# m1_92_496# sky130_fd_sc_hd__inv_2
X_254_ VSUBS m1_92_1040# m1_92_496# li_8493_5185# m1_92_496# li_6929_3893# li_9873_7293#
+ sky130_fd_sc_hd__nor2_1
X_185_ VSUBS m1_92_496# li_1961_3009# m1_92_1040# li_857_3417# m1_92_496# sky130_fd_sc_hd__inv_2
X_323_ VSUBS li_2145_2397# m1_92_496# m1_92_1040# m1_92_496# li_581_3553# li_1225_901#
+ li_1133_4029# sky130_fd_sc_hd__dfrtp_1
X_168_ VSUBS m1_92_1040# li_11713_6273# li_11529_9537# li_11529_9537# m1_92_496# m1_92_496#
+ li_11437_9537# li_11437_9537# sky130_fd_sc_hd__a2bb2oi_1
X_237_ VSUBS m1_92_496# li_949_11101# li_2329_11101# m1_92_496# li_8769_12393# m1_92_1040#
+ li_6929_11169# sky130_fd_sc_hd__a21oi_1
X_306_ VSUBS li_9873_5117# m1_92_496# m1_92_1040# m1_92_496# li_1317_3009# li_11437_5253#
+ li_1133_3009# sky130_fd_sc_hd__mux2_1
XFILLER_19_156 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_15_49 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
Xoutput37 VSUBS m1_92_496# li_14381_9673# m1_92_496# li_15117_9945# m1_92_1040# sky130_fd_sc_hd__clkbuf_2
XFILLER_16_115 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_6
Xoutput15 VSUBS m1_92_496# li_2329_833# m1_92_496# li_3249_12869# m1_92_1040# sky130_fd_sc_hd__clkbuf_2
Xoutput26 VSUBS m1_92_496# li_673_10693# m1_92_496# li_489_10489# m1_92_1040# sky130_fd_sc_hd__clkbuf_2
XFILLER_22_107 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_8
XFILLER_21_81 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XPHY_1 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_3
Xclkbuf_2_3_0_clk VSUBS li_7573_11713# m1_92_1040# li_9689_9401# m1_92_496# m1_92_496#
+ sky130_fd_sc_hd__clkbuf_1
XFILLER_8_155 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_16_70 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
X_270_ VSUBS m1_92_1040# li_2329_833# m1_92_496# li_2145_7701# li_673_7769# m1_92_496#
+ sky130_fd_sc_hd__or2_2
X_322_ VSUBS li_1869_12801# m1_92_496# m1_92_1040# m1_92_496# li_581_12189# li_1225_901#
+ li_857_12121# sky130_fd_sc_hd__dfrtp_1
XFILLER_13_82 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
X_253_ VSUBS m1_92_496# li_9505_7293# m1_92_1040# li_9873_7293# m1_92_496# sky130_fd_sc_hd__inv_2
X_184_ VSUBS li_1961_3009# m1_92_496# m1_92_1040# m1_92_496# li_3709_5253# li_3709_4505#
+ li_3893_5661# sky130_fd_sc_hd__mux2_1
X_236_ VSUBS m1_92_1040# m1_92_496# li_8677_11305# m1_92_496# li_8677_11101# li_765_10013#
+ sky130_fd_sc_hd__nor2_1
X_167_ VSUBS m1_92_1040# li_4537_7225# li_11069_7701# m1_92_496# m1_92_496# li_11529_9537#
+ li_9965_7361# li_11433_7769# sky130_fd_sc_hd__a22o_1
X_305_ VSUBS li_7573_4165# m1_92_496# m1_92_1040# m1_92_496# li_1317_3009# li_6929_3893#
+ li_1133_3009# sky130_fd_sc_hd__mux2_1
XFILLER_1_30 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
X_219_ VSUBS li_7573_11305# m1_92_496# li_7297_11033# li_5871_12121# li_4629_10693#
+ m1_92_496# m1_92_1040# li_5550_12189# li_6929_11169# sky130_fd_sc_hd__a32o_1
Xoutput38 VSUBS m1_92_496# li_14381_11849# m1_92_496# li_15117_12121# m1_92_1040#
+ sky130_fd_sc_hd__clkbuf_2
XFILLER_16_105 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_8
Xoutput16 VSUBS m1_92_496# li_3893_8857# m1_92_496# li_4905_12937# m1_92_1040# sky130_fd_sc_hd__clkbuf_2
Xoutput27 VSUBS m1_92_496# li_949_11101# m1_92_496# li_765_11237# m1_92_1040# sky130_fd_sc_hd__clkbuf_2
Xclkbuf_0_clk VSUBS m1_92_1040# li_8401_7429# m1_92_496# m1_92_496# li_6653_7361#
+ sky130_fd_sc_hd__clkbuf_16
XPHY_2 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_3
XFILLER_7_62 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_6
XFILLER_16_82 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_5_115 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_4_85 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_4_52 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_2_129 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
Xclkbuf_2_2_0_clk VSUBS li_6653_1377# m1_92_1040# li_9689_9401# m1_92_496# m1_92_496#
+ sky130_fd_sc_hd__clkbuf_1
X_183_ VSUBS li_3893_5661# li_3709_5253# li_1409_7769# li_4721_10625# li_3801_4165#
+ m1_92_496# m1_92_496# li_6193_6749# m1_92_1040# sky130_fd_sc_hd__o221ai_4
X_321_ VSUBS li_673_11781# m1_92_496# m1_92_1040# m1_92_496# li_7573_11713# li_7297_12121#
+ li_8677_11305# sky130_fd_sc_hd__dfrtp_1
X_252_ VSUBS li_3525_9537# li_7297_6953# m1_92_1040# li_7389_7973# m1_92_496# m1_92_496#
+ li_7573_7837# sky130_fd_sc_hd__o21ai_1
X_235_ VSUBS m1_92_496# li_673_11781# li_2329_11101# m1_92_496# li_8677_11101# m1_92_1040#
+ li_7297_11033# sky130_fd_sc_hd__a21oi_1
X_304_ VSUBS li_949_2261# m1_92_1040# li_3433_7497# li_4905_9537# m1_92_496# m1_92_496#
+ li_5550_12189# sky130_fd_sc_hd__mux2_2
X_166_ VSUBS m1_92_496# li_11433_7769# m1_92_1040# li_11069_7701# m1_92_496# sky130_fd_sc_hd__inv_2
XFILLER_1_20 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_8
XFILLER_19_82 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
X_218_ VSUBS li_9229_10421# m1_92_496# li_4905_9537# li_5871_12121# li_3433_12053#
+ m1_92_496# m1_92_1040# li_5550_12189# li_7297_11033# sky130_fd_sc_hd__a32o_1
X_149_ VSUBS m1_92_496# li_2166_5525# m1_92_496# li_3709_5253# m1_92_1040# sky130_fd_sc_hd__clkbuf_2
Xoutput39 VSUBS m1_92_496# li_14197_12801# m1_92_496# li_14381_12869# m1_92_1040#
+ sky130_fd_sc_hd__clkbuf_2
Xoutput17 VSUBS m1_92_496# li_3893_10557# m1_92_496# li_6929_12869# m1_92_1040# sky130_fd_sc_hd__clkbuf_2
Xoutput28 VSUBS m1_92_496# li_673_11781# m1_92_496# li_489_11781# m1_92_1040# sky130_fd_sc_hd__clkbuf_2
XFILLER_16_128 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XPHY_3 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_3
XFILLER_7_30 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_21_131 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_12
XFILLER_21_164 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_12_164 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_8_124 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_4_42 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
X_251_ VSUBS li_7297_6953# m1_92_496# m1_92_1040# m1_92_496# li_1409_7769# li_6653_6749#
+ li_3709_5661# li_4721_10625# sky130_fd_sc_hd__o211a_1
X_320_ VSUBS li_949_11101# m1_92_496# m1_92_1040# m1_92_496# li_7573_11713# li_7297_12121#
+ li_9413_11033# sky130_fd_sc_hd__dfrtp_1
X_182_ VSUBS li_3709_4505# m1_92_496# m1_92_1040# m1_92_496# li_1593_4573# li_4721_10625#
+ li_4721_4097# li_1317_3009# sky130_fd_sc_hd__o211a_1
X_303_ VSUBS m1_92_496# li_9321_8925# m1_92_1040# li_8677_8517# m1_92_496# sky130_fd_sc_hd__inv_2
X_165_ VSUBS li_11437_9537# m1_92_496# li_12725_6681# m1_92_1040# li_9965_7361# m1_92_496#
+ li_12725_6273# li_14289_7837# sky130_fd_sc_hd__o22a_1
X_234_ VSUBS m1_92_1040# m1_92_496# li_857_12121# m1_92_496# li_1593_10013# li_765_10013#
+ sky130_fd_sc_hd__nor2_1
Xclkbuf_2_1_0_clk VSUBS li_581_12189# m1_92_1040# li_1409_1921# m1_92_496# m1_92_496#
+ sky130_fd_sc_hd__clkbuf_1
XFILLER_1_87 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_8
XFILLER_19_94 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
X_217_ VSUBS li_4353_10625# li_5871_12121# m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__buf_1
X_148_ VSUBS m1_92_496# li_397_3009# m1_92_1040# li_489_6069# m1_92_496# sky130_fd_sc_hd__inv_2
Xoutput18 VSUBS m1_92_496# li_6285_12733# m1_92_496# li_8953_12869# m1_92_1040# sky130_fd_sc_hd__clkbuf_2
Xoutput29 VSUBS m1_92_496# li_1869_12801# m1_92_496# li_1777_12937# m1_92_1040# sky130_fd_sc_hd__clkbuf_2
XFILLER_21_95 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XPHY_4 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_3
XFILLER_12_110 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_5_139 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_4_21 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_13_30 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_8
XFILLER_13_74 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
X_181_ VSUBS m1_92_496# li_5181_3689# m1_92_496# li_4721_10625# m1_92_1040# sky130_fd_sc_hd__clkbuf_2
X_250_ VSUBS li_6653_6749# m1_92_496# li_4905_1921# m1_92_1040# li_6009_6273# m1_92_496#
+ li_7205_5661# li_6837_5661# sky130_fd_sc_hd__o22a_1
X_164_ VSUBS m1_92_496# li_12817_6749# m1_92_1040# li_12725_6681# m1_92_496# sky130_fd_sc_hd__inv_2
X_302_ VSUBS m1_92_496# li_10517_6817# m1_92_1040# li_9873_7293# li_3801_6613# m1_92_496#
+ li_9229_7225# li_9321_8925# li_6193_6749# sky130_fd_sc_hd__o32a_1
X_233_ VSUBS m1_92_496# li_1869_12801# li_2329_11101# m1_92_496# li_1593_10013# m1_92_1040#
+ li_3433_12053# sky130_fd_sc_hd__a21oi_1
XFILLER_19_127 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_8
XFILLER_19_138 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_10_53 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
X_216_ VSUBS m1_92_496# li_6009_6273# m1_92_496# li_5550_12189# m1_92_1040# sky130_fd_sc_hd__clkbuf_2
X_147_ VSUBS m1_92_496# li_3801_6613# m1_92_1040# li_6929_4573# m1_92_496# sky130_fd_sc_hd__inv_2
Xoutput19 VSUBS m1_92_496# li_11253_10625# m1_92_496# li_11253_12869# m1_92_1040#
+ sky130_fd_sc_hd__clkbuf_2
XFILLER_21_52 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_21_30 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XPHY_5 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_3
XFILLER_7_87 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_8
Xclkbuf_2_0_0_clk VSUBS li_581_3553# m1_92_1040# li_1409_1921# m1_92_496# m1_92_496#
+ sky130_fd_sc_hd__clkbuf_1
XFILLER_7_10 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_7_76 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_8
XFILLER_21_144 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_12
XFILLER_16_96 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_6
XFILLER_8_115 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_5_107 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_4_77 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
X_180_ VSUBS li_489_6069# m1_92_1040# li_3801_4165# m1_92_496# li_2605_3145# m1_92_496#
+ li_5181_3689# sky130_fd_sc_hd__or3_1
X_301_ VSUBS li_9965_7361# li_4537_7225# m1_92_496# m1_92_1040# li_9137_7293# li_9873_7293#
+ li_10517_6817# m1_92_496# li_9505_7293# sky130_fd_sc_hd__o221a_1
X_163_ VSUBS li_12817_6749# m1_92_496# li_4537_7225# m1_92_1040# li_14197_7905# m1_92_496#
+ li_12173_7769# li_14289_7837# sky130_fd_sc_hd__o22a_1
X_232_ VSUBS m1_92_496# li_1777_6749# m1_92_496# li_2329_11101# m1_92_1040# sky130_fd_sc_hd__clkbuf_2
XFILLER_1_45 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_19_30 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_8
X_146_ VSUBS m1_92_1040# li_397_3009# m1_92_496# m1_92_496# li_3617_6681# li_3801_6613#
+ li_1961_5593# sky130_fd_sc_hd__and3_2
X_215_ VSUBS m1_92_496# li_5181_3689# m1_92_1040# li_6009_6273# m1_92_496# sky130_fd_sc_hd__inv_2
XFILLER_15_164 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XPHY_6 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_3
XFILLER_7_22 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_6
XFILLER_7_44 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_8
XFILLER_21_156 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_16_31 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_16_53 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_4_163 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_13_87 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_13_54 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_1_144 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_12
XFILLER_8_3 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_6
X_162_ VSUBS m1_92_496# li_14933_6749# m1_92_496# li_4537_7225# m1_92_1040# sky130_fd_sc_hd__clkbuf_2
X_300_ VSUBS m1_92_1040# li_9965_7361# li_4537_7225# li_9873_7293# m1_92_496# li_9229_7225#
+ m1_92_496# li_9505_7293# li_9137_7293# sky130_fd_sc_hd__a221oi_2
X_231_ VSUBS li_1777_6749# li_3617_6681# li_581_2805# li_3709_5253# m1_92_496# m1_92_1040#
+ li_3801_4165# m1_92_496# li_4537_7225# sky130_fd_sc_hd__o2111a_1
XFILLER_1_13 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_19_118 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_10_99 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_6
Xinput1 VSUBS li_1685_2601# m1_92_1040# li_1501_2397# m1_92_496# m1_92_496# sky130_fd_sc_hd__clkbuf_1
XFILLER_10_33 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
X_214_ VSUBS m1_92_1040# li_4721_10625# li_3433_12053# m1_92_496# m1_92_496# li_4905_10761#
+ li_4353_10625# li_4629_10693# sky130_fd_sc_hd__a22o_1
X_145_ VSUBS li_3433_7497# li_3617_6681# m1_92_496# li_4813_8449# m1_92_1040# m1_92_496#
+ sky130_fd_sc_hd__nand2_1
XFILLER_21_87 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_21_65 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XPHY_7 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_3
XFILLER_12_157 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_4_35 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_13_44 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_6
XFILLER_1_156 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_12
X_230_ VSUBS m1_92_496# li_1961_4641# m1_92_496# li_765_10013# m1_92_1040# sky130_fd_sc_hd__clkbuf_2
X_161_ VSUBS m1_92_496# li_12817_6273# m1_92_1040# li_12725_6273# m1_92_496# sky130_fd_sc_hd__inv_2
Xinput2 VSUBS li_15117_9537# li_14933_6749# m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__buf_1
XFILLER_19_87 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_19_43 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
X_144_ VSUBS li_2329_5865# li_3433_7497# m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__buf_1
X_213_ VSUBS m1_92_496# li_4905_9537# m1_92_1040# li_4353_10625# m1_92_496# sky130_fd_sc_hd__inv_2
XFILLER_15_144 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_15_155 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XPHY_8 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_3
XFILLER_4_110 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_4_154 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_4_58 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_4_14 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_4_69 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_1_124 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_12
XFILLER_13_67 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
X_160_ VSUBS m1_92_496# li_14197_7905# m1_92_496# li_9965_7361# m1_92_1040# sky130_fd_sc_hd__clkbuf_2
X_289_ VSUBS m1_92_1040# li_14473_11713# m1_92_496# li_10701_1173# li_12817_3417#
+ m1_92_496# sky130_fd_sc_hd__or2_2
Xinput3 VSUBS m1_92_496# li_857_2397# m1_92_496# li_949_2261# m1_92_1040# sky130_fd_sc_hd__clkbuf_2
X_212_ VSUBS li_4905_9537# li_4629_10693# m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__buf_1
XFILLER_19_11 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_8
X_143_ VSUBS li_2329_5865# m1_92_496# li_397_3009# li_1961_5593# m1_92_1040# m1_92_496#
+ li_2166_5525# sky130_fd_sc_hd__and3_1
XFILLER_10_46 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_21_45 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_15_101 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_15_134 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_8
XPHY_9 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_3
XFILLER_16_89 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_12_115 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_16_45 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_7_163 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_1_136 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_6
XFILLER_1_38 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_6_3 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
X_288_ VSUBS m1_92_496# li_14289_4709# m1_92_1040# li_14381_9673# m1_92_496# sky130_fd_sc_hd__inv_2
Xinput4 VSUBS li_1225_901# li_397_833# m1_92_496# m1_92_1040# m1_92_496# sky130_fd_sc_hd__buf_8
XFILLER_19_67 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_6
X_211_ VSUBS m1_92_1040# li_3525_1309# li_3801_2873# m1_92_496# m1_92_496# li_7389_2261#
+ li_6837_2397# li_3893_3009# sky130_fd_sc_hd__a22o_1
XFILLER_10_58 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
X_142_ VSUBS m1_92_496# li_2329_3553# m1_92_1040# li_2166_5525# m1_92_496# sky130_fd_sc_hd__inv_2
XFILLER_18_8 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_12_127 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_8
XFILLER_13_25 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
X_287_ VSUBS m1_92_1040# li_14289_4709# m1_92_496# li_9137_2601# li_12817_4505# m1_92_496#
+ sky130_fd_sc_hd__or2_2
XFILLER_18_122 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_12
XFILLER_18_100 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
X_210_ VSUBS li_1133_3009# li_4077_1377# m1_92_1040# li_5825_3145# li_5825_3689# m1_92_496#
+ m1_92_496# li_3433_1173# sky130_fd_sc_hd__o22ai_1
X_141_ VSUBS m1_92_496# li_949_2261# m1_92_1040# li_4813_8449# m1_92_496# sky130_fd_sc_hd__inv_2
X_339_ VSUBS li_9735_3417# m1_92_496# m1_92_1040# m1_92_496# li_6653_1377# li_7297_12121#
+ li_8677_1989# sky130_fd_sc_hd__dfrtp_1
XFILLER_21_25 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_16_58 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_14_3 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_4_28 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_1_116 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
X_286_ VSUBS li_1317_3009# li_949_5593# m1_92_496# li_1133_3009# m1_92_1040# m1_92_496#
+ sky130_fd_sc_hd__nand2_1
XFILLER_19_25 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_18_134 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_12
X_140_ VSUBS m1_92_496# li_2973_5117# m1_92_1040# li_1961_5593# m1_92_496# sky130_fd_sc_hd__inv_2
X_338_ VSUBS li_10701_1173# m1_92_496# m1_92_1040# m1_92_496# li_6653_1377# li_7297_12121#
+ li_9229_1377# sky130_fd_sc_hd__dfrtp_1
X_269_ VSUBS m1_92_496# li_1133_12801# m1_92_1040# li_1133_1241# m1_92_496# sky130_fd_sc_hd__inv_2
XFILLER_16_7 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_7_155 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_7_144 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_6
XFILLER_8_82 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_6
XFILLER_8_71 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_17_80 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_6
X_285_ VSUBS m1_92_496# li_14381_10013# m1_92_1040# li_14289_10217# m1_92_496# sky130_fd_sc_hd__inv_2
XFILLER_18_146 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_12
Xclkbuf_1_1_0_clk VSUBS li_9689_9401# m1_92_1040# li_8401_7429# m1_92_496# m1_92_496#
+ sky130_fd_sc_hd__clkbuf_1
X_268_ VSUBS m1_92_1040# li_1133_12801# m1_92_496# li_1409_7769# li_489_7497# m1_92_496#
+ sky130_fd_sc_hd__or2_2
X_337_ VSUBS li_9137_2601# m1_92_496# m1_92_1040# m1_92_496# li_6653_1377# li_7297_12121#
+ li_10609_2465# sky130_fd_sc_hd__dfrtp_1
X_199_ VSUBS li_9229_1377# m1_92_496# li_6837_2397# li_10701_1173# li_9735_3417# m1_92_496#
+ m1_92_1040# li_9321_833# li_8677_2533# sky130_fd_sc_hd__a32o_1
XFILLER_21_38 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_21_119 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_12
XFILLER_16_38 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_11_163 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_4_115 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_13_17 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_5_95 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
X_284_ VSUBS m1_92_1040# li_14381_10013# m1_92_496# li_7205_5661# li_14289_5117# m1_92_496#
+ sky130_fd_sc_hd__or2_2
XFILLER_18_158 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_8
X_336_ VSUBS li_6837_4641# m1_92_496# m1_92_1040# m1_92_496# li_6653_1377# li_7297_12121#
+ li_9229_4505# sky130_fd_sc_hd__dfrtp_1
X_267_ VSUBS m1_92_1040# m1_92_496# li_12725_5525# m1_92_496# li_12817_5661# li_9137_6205#
+ sky130_fd_sc_hd__nor2_1
X_198_ VSUBS li_8677_1989# m1_92_496# li_6837_2397# li_9735_3417# li_9505_901# m1_92_496#
+ m1_92_1040# li_9321_833# li_8677_2533# sky130_fd_sc_hd__a32o_1
XFILLER_2_85 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
X_319_ VSUBS li_673_10693# m1_92_496# m1_92_1040# m1_92_496# li_581_12189# li_1225_901#
+ li_2697_10693# sky130_fd_sc_hd__dfrtp_1
XFILLER_20_164 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_11_131 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
Xclkbuf_1_0_0_clk VSUBS li_1409_1921# m1_92_1040# li_8401_7429# m1_92_496# m1_92_496#
+ sky130_fd_sc_hd__clkbuf_1
XFILLER_8_40 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_4_127 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_6
XFILLER_0_141 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_5_30 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_14_83 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_6
X_283_ VSUBS m1_92_496# li_4353_11781# m1_92_1040# li_14289_11033# m1_92_496# sky130_fd_sc_hd__inv_2
XFILLER_18_115 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
X_266_ VSUBS m1_92_496# li_14289_5117# li_8953_5049# m1_92_496# li_12817_5661# m1_92_1040#
+ li_7205_5661# sky130_fd_sc_hd__a21oi_1
X_197_ VSUBS m1_92_496# li_6837_5661# m1_92_496# li_6837_2397# m1_92_1040# sky130_fd_sc_hd__clkbuf_2
X_335_ VSUBS li_4537_3009# m1_92_496# m1_92_1040# m1_92_496# li_581_3553# li_1225_901#
+ li_3525_2465# sky130_fd_sc_hd__dfrtp_1
XFILLER_2_53 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
X_249_ VSUBS m1_92_496# li_8493_8041# m1_92_1040# li_7573_7837# m1_92_496# sky130_fd_sc_hd__inv_2
X_318_ VSUBS li_581_9605# m1_92_496# m1_92_1040# m1_92_496# li_581_12189# li_1225_901#
+ li_949_10217# sky130_fd_sc_hd__dfrtp_1
XFILLER_17_94 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_6
XFILLER_0_164 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
X_282_ VSUBS m1_92_1040# li_4353_11781# m1_92_496# li_3433_12053# li_1869_12801# m1_92_496#
+ sky130_fd_sc_hd__or2_2
XFILLER_4_6 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
X_334_ VSUBS li_3617_1853# m1_92_496# m1_92_1040# m1_92_496# li_581_3553# li_1225_901#
+ li_2145_1853# sky130_fd_sc_hd__dfrtp_1
X_265_ VSUBS m1_92_1040# m1_92_496# li_12909_4029# m1_92_496# li_12817_4777# li_9137_6205#
+ sky130_fd_sc_hd__nor2_1
X_196_ VSUBS m1_92_496# li_4721_4097# m1_92_1040# li_6837_5661# m1_92_496# sky130_fd_sc_hd__inv_2
XFILLER_11_30 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_6
XFILLER_14_163 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
X_317_ VSUBS li_949_8857# m1_92_496# m1_92_1040# m1_92_496# li_581_12189# li_1225_901#
+ li_2605_9469# sky130_fd_sc_hd__dfrtp_1
X_179_ VSUBS m1_92_496# li_2329_2397# m1_92_496# li_1317_3009# m1_92_1040# sky130_fd_sc_hd__clkbuf_2
XFILLER_2_3 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_8
X_248_ VSUBS m1_92_1040# m1_92_496# li_1961_7429# m1_92_496# li_1501_6885# li_1961_4641#
+ sky130_fd_sc_hd__nor2_1
XFILLER_11_144 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_11_155 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_8_97 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_8_53 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_5_87 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_5_76 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_8
XFILLER_5_65 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_6
X_281_ VSUBS m1_92_496# li_11529_11781# m1_92_1040# li_12633_11033# m1_92_496# sky130_fd_sc_hd__inv_2
XFILLER_14_52 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XPHY_40 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_3
X_195_ VSUBS m1_92_1040# li_9321_833# li_9505_901# m1_92_496# m1_92_496# li_8677_2941#
+ li_8677_2533# li_1133_3009# sky130_fd_sc_hd__a22o_1
X_264_ VSUBS m1_92_496# li_12817_4505# li_8953_5049# m1_92_496# li_12817_4777# m1_92_1040#
+ li_9137_2601# sky130_fd_sc_hd__a21oi_1
X_333_ VSUBS m1_92_496# m1_92_1040# m1_92_496# li_6653_1377# li_4169_1309# li_1225_901#
+ li_5825_3689# sky130_fd_sc_hd__dfrtp_4
XFILLER_15_109 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
X_247_ VSUBS m1_92_496# li_489_7497# li_1777_6749# m1_92_496# li_1501_6885# m1_92_1040#
+ li_1409_7769# sky130_fd_sc_hd__a21oi_1
XFILLER_11_42 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
X_316_ VSUBS li_673_7769# m1_92_496# m1_92_1040# m1_92_496# li_581_12189# li_1225_901#
+ li_2237_8381# sky130_fd_sc_hd__dfrtp_1
X_178_ VSUBS li_2605_3145# li_2329_2397# li_3801_4165# m1_92_1040# m1_92_496# li_397_3009#
+ m1_92_496# sky130_fd_sc_hd__or3_4
XFILLER_22_30 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_7_116 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_8_32 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_17_30 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_3_130 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_6
XFILLER_3_152 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_8
X_280_ VSUBS li_7297_11033# li_11529_11781# li_673_11781# m1_92_1040# m1_92_496# m1_92_496#
+ sky130_fd_sc_hd__or2_1
XPHY_41 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_3
XPHY_30 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_3
X_194_ VSUBS li_7757_3893# li_8677_2533# m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__buf_1
X_263_ VSUBS m1_92_1040# m1_92_496# li_12633_2601# m1_92_496# li_12633_2397# li_9137_6205#
+ sky130_fd_sc_hd__nor2_1
X_332_ VSUBS m1_92_496# m1_92_1040# m1_92_496# li_6653_1377# li_3893_3009# li_1225_901#
+ li_7389_2261# sky130_fd_sc_hd__dfrtp_4
XFILLER_17_140 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_3
XFILLER_11_87 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_6
XFILLER_11_98 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_6
XFILLER_14_110 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_20_157 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
X_246_ VSUBS m1_92_1040# m1_92_496# li_2237_8381# m1_92_496# li_2329_8041# li_1961_4641#
+ sky130_fd_sc_hd__nor2_1
X_177_ VSUBS m1_92_496# li_1961_5593# m1_92_496# li_3801_4165# m1_92_1040# sky130_fd_sc_hd__clkbuf_2
X_315_ VSUBS li_489_7497# m1_92_496# m1_92_1040# m1_92_496# li_581_3553# li_1225_901#
+ li_1961_7429# sky130_fd_sc_hd__dfrtp_1
XFILLER_7_139 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
X_229_ VSUBS li_1685_2601# li_1133_4029# m1_92_496# m1_92_1040# li_1685_4573# m1_92_496#
+ li_1593_4573# li_1961_4641# sky130_fd_sc_hd__a2bb2o_1
XFILLER_3_164 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_0_112 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_0_156 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_5_56 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
X_331_ VSUBS li_3433_12053# m1_92_496# m1_92_1040# m1_92_496# li_581_12189# li_7297_12121#
+ li_4905_10761# sky130_fd_sc_hd__dfrtp_1
XFILLER_18_108 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_6
XPHY_31 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_3
XPHY_42 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_3
X_262_ VSUBS m1_92_496# li_12817_3417# li_8953_5049# m1_92_496# li_12633_2397# m1_92_1040#
+ li_10701_1173# sky130_fd_sc_hd__a21oi_1
X_193_ VSUBS m1_92_496# li_7757_3893# m1_92_1040# li_9321_833# m1_92_496# sky130_fd_sc_hd__inv_2
XPHY_20 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_3
XFILLER_11_11 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
X_314_ VSUBS li_8493_8041# m1_92_496# m1_92_1040# m1_92_496# li_7573_11713# li_7297_12121#
+ li_7389_7973# sky130_fd_sc_hd__dfrtp_1
X_245_ VSUBS m1_92_496# li_673_7769# li_1777_6749# m1_92_496# li_2329_8041# m1_92_1040#
+ li_2145_7701# sky130_fd_sc_hd__a21oi_1
X_176_ VSUBS li_2329_3553# li_2605_3145# m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__buf_1
XFILLER_11_114 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_8
XFILLER_20_125 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_12
XFILLER_22_54 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_22_21 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_8
XFILLER_7_129 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_6
X_159_ VSUBS m1_92_496# li_14933_6749# m1_92_1040# li_14197_7905# m1_92_496# sky130_fd_sc_hd__inv_2
X_228_ VSUBS m1_92_496# li_3525_9537# m1_92_1040# li_1961_4641# m1_92_496# sky130_fd_sc_hd__inv_2
XFILLER_17_87 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_17_10 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_0_146 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_6
X_330_ VSUBS li_7297_11033# m1_92_496# m1_92_1040# m1_92_496# li_7573_11713# li_7297_12121#
+ li_9229_10421# sky130_fd_sc_hd__dfrtp_1
XPHY_43 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_3
XPHY_32 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_3
XPHY_21 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_3
X_261_ VSUBS m1_92_1040# m1_92_496# li_11989_3349# m1_92_496# li_9137_6205# li_12081_3485#
+ sky130_fd_sc_hd__nor2_1
X_192_ VSUBS li_7573_4165# li_7757_3893# li_2329_2601# m1_92_1040# m1_92_496# m1_92_496#
+ sky130_fd_sc_hd__or2_1
XPHY_10 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_3
XFILLER_17_164 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_2_58 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_11_67 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_14_156 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
X_244_ VSUBS m1_92_1040# m1_92_496# li_2605_9469# m1_92_496# li_2329_9061# li_1961_4641#
+ sky130_fd_sc_hd__nor2_1
X_313_ VSUBS li_9781_5253# m1_92_496# m1_92_1040# m1_92_496# li_6653_1377# li_7297_12121#
+ li_9413_5321# sky130_fd_sc_hd__dfrtp_1
X_175_ VSUBS m1_92_496# li_2145_2397# m1_92_1040# li_1593_4573# m1_92_496# sky130_fd_sc_hd__inv_2
XFILLER_20_137 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_12
XFILLER_20_115 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_22_88 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_8
X_158_ VSUBS m1_92_496# li_12173_7769# m1_92_1040# li_14289_7837# m1_92_496# sky130_fd_sc_hd__inv_2
X_227_ VSUBS li_3433_7497# li_3525_9537# m1_92_496# li_949_2261# m1_92_1040# m1_92_496#
+ sky130_fd_sc_hd__nand2_1
XFILLER_6_130 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_6
XFILLER_3_144 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_0_125 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_12
XFILLER_5_47 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_5_25 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_10_6 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_14_45 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XPHY_22 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_3
XPHY_33 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_3
XPHY_44 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_3
X_260_ VSUBS li_9137_6205# m1_92_1040# m1_92_496# li_7573_5117# li_6837_5661# m1_92_496#
+ sky130_fd_sc_hd__nor2_2
XPHY_11 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_3
XFILLER_17_121 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
X_191_ VSUBS m1_92_1040# m1_92_496# li_2329_2601# m1_92_496# li_2329_2397# li_2145_2397#
+ sky130_fd_sc_hd__nor2_1
XFILLER_2_15 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_11_79 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_6
X_243_ VSUBS m1_92_496# li_949_8857# li_1777_6749# m1_92_496# li_2329_9061# m1_92_1040#
+ li_2145_8789# sky130_fd_sc_hd__a21oi_1
X_312_ VSUBS li_13737_2397# m1_92_496# m1_92_1040# m1_92_496# li_6653_1377# li_7297_12121#
+ li_11989_3349# sky130_fd_sc_hd__dfrtp_1
X_174_ VSUBS m1_92_1040# li_3709_5661# li_12725_6273# m1_92_496# m1_92_496# li_13001_7293#
+ li_3801_6613# li_12817_6273# sky130_fd_sc_hd__a22o_1
XFILLER_20_149 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_3_80 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_6
XFILLER_22_78 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_8
X_157_ VSUBS m1_92_496# li_6193_6749# m1_92_496# li_3709_5661# m1_92_1040# sky130_fd_sc_hd__clkbuf_2
XFILLER_19_3 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_6_164 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_8_58 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
X_226_ VSUBS li_1685_4573# m1_92_496# li_3709_5253# m1_92_1040# li_3801_6613# m1_92_496#
+ li_4261_3621# sky130_fd_sc_hd__o21a_1
X_209_ VSUBS m1_92_1040# li_3893_3009# li_4077_1377# m1_92_496# m1_92_496# li_5825_3145#
+ li_3801_2873# li_4169_1309# sky130_fd_sc_hd__a22o_1
XFILLER_5_37 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XPHY_12 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_3
XPHY_23 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_3
XFILLER_17_144 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_8
XPHY_45 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_3
XPHY_34 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_3
X_190_ VSUBS m1_92_496# li_4905_1921# m1_92_496# li_1133_3009# m1_92_1040# sky130_fd_sc_hd__clkbuf_2
X_173_ VSUBS li_12173_7769# li_12817_8041# m1_92_496# m1_92_1040# li_12541_7837# m1_92_496#
+ li_6929_4573# li_6929_4573# sky130_fd_sc_hd__a2bb2o_1
X_242_ VSUBS m1_92_1040# m1_92_496# li_949_10217# m1_92_496# li_949_10013# li_765_10013#
+ sky130_fd_sc_hd__nor2_1
X_311_ VSUBS li_12817_3417# m1_92_496# m1_92_1040# m1_92_496# li_6653_1377# li_7297_12121#
+ li_12633_2601# sky130_fd_sc_hd__dfrtp_1
XFILLER_20_106 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_8
XFILLER_9_151 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_8
XFILLER_11_139 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_22_68 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_6
XFILLER_22_13 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
X_156_ VSUBS m1_92_1040# li_6193_6749# m1_92_496# li_4721_4097# li_6745_4641# m1_92_496#
+ sky130_fd_sc_hd__or2_2
X_225_ VSUBS li_4261_3621# m1_92_1040# m1_92_496# m1_92_496# li_6745_4641# li_6837_4641#
+ sky130_fd_sc_hd__and2_1
XFILLER_17_68 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
X_208_ VSUBS li_2145_1853# m1_92_496# li_4721_833# m1_92_1040# li_4721_1989# m1_92_496#
+ li_3617_1853# li_3525_1309# sky130_fd_sc_hd__o22a_1
XFILLER_9_80 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_6
XFILLER_0_105 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_14_36 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_6
XFILLER_14_58 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XPHY_35 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_3
XPHY_24 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_3
XPHY_13 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_3
XFILLER_9_3 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_2_39 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_17_156 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_14_115 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
X_310_ VSUBS li_12817_4505# m1_92_496# m1_92_1040# m1_92_496# li_6653_1377# li_7297_12121#
+ li_12909_4029# sky130_fd_sc_hd__dfrtp_1
X_241_ VSUBS m1_92_496# li_581_9605# li_2329_11101# m1_92_496# li_949_10013# m1_92_1040#
+ li_2237_11033# sky130_fd_sc_hd__a21oi_1
X_172_ VSUBS m1_92_1040# m1_92_496# li_12541_7837# m1_92_496# li_14197_6273# li_3709_5661#
+ sky130_fd_sc_hd__nor2_1
XFILLER_12_91 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_6
X_155_ VSUBS m1_92_496# li_6929_3893# m1_92_1040# li_6745_4641# m1_92_496# sky130_fd_sc_hd__inv_2
X_224_ VSUBS li_5825_6409# m1_92_496# li_2145_7701# li_4353_10625# li_4905_9537# m1_92_496#
+ m1_92_1040# li_6009_6273# li_1409_7769# sky130_fd_sc_hd__a32o_1
XFILLER_17_25 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
X_207_ VSUBS li_4721_833# m1_92_496# li_3893_3009# li_4169_1309# m1_92_1040# m1_92_496#
+ li_3433_1173# sky130_fd_sc_hd__and3_1
XFILLER_0_83 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_0_117 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XPHY_25 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_3
XPHY_36 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_3
XPHY_14 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_3
X_171_ VSUBS li_14197_6273# m1_92_496# li_12817_6749# m1_92_1040# li_12725_6681# m1_92_496#
+ li_12817_6273# li_12725_6273# sky130_fd_sc_hd__o22a_1
X_240_ VSUBS m1_92_1040# m1_92_496# li_2697_10693# m1_92_496# li_3985_11305# li_765_10013#
+ sky130_fd_sc_hd__nor2_1
XFILLER_3_94 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_9_164 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_22_59 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
X_223_ VSUBS li_6469_8993# m1_92_496# li_2145_8789# li_4353_10625# li_4905_9537# m1_92_496#
+ m1_92_1040# li_6009_6273# li_2145_7701# sky130_fd_sc_hd__a32o_1
XFILLER_6_123 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_10_163 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_6_156 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
X_154_ VSUBS li_6285_2601# li_6929_3893# m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__buf_1
X_206_ VSUBS m1_92_496# li_3525_1309# m1_92_1040# li_3433_1173# m1_92_496# sky130_fd_sc_hd__inv_2
XFILLER_17_3 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_14_27 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XPHY_37 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_3
XPHY_26 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_3
XPHY_15 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_3
XFILLER_15_81 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_14_128 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_6
X_170_ VSUBS li_11433_7769# li_10885_8925# m1_92_496# m1_92_1040# li_11437_8449# m1_92_496#
+ li_6929_4573# li_6929_4573# sky130_fd_sc_hd__a2bb2o_1
X_299_ VSUBS li_9137_7293# m1_92_496# li_11529_9537# m1_92_1040# li_9965_7361# m1_92_496#
+ li_11437_9537# li_11069_7701# sky130_fd_sc_hd__o22a_1
XFILLER_22_38 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_12
X_222_ VSUBS li_5825_9673# m1_92_496# li_2237_11033# li_5871_12121# li_4629_10693#
+ m1_92_496# m1_92_1040# li_6009_6273# li_2145_8789# sky130_fd_sc_hd__a32o_1
XFILLER_10_142 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
X_153_ VSUBS li_4537_3009# m1_92_1040# li_3801_2873# m1_92_496# m1_92_496# li_6285_2601#
+ li_3617_1853# li_4077_1377# sky130_fd_sc_hd__or4b_4
XFILLER_17_38 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_8
X_205_ VSUBS li_3525_2465# m1_92_496# li_3525_1309# m1_92_1040# li_4537_3009# m1_92_496#
+ li_4721_1989# sky130_fd_sc_hd__o21a_1
XFILLER_0_30 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_20_82 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_6_84 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XPHY_27 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_3
XPHY_38 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_3
XPHY_16 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_3
XFILLER_7_3 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_3
XFILLER_9_144 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_3_30 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
X_298_ VSUBS li_857_4505# m1_92_496# li_489_6069# li_3801_4165# m1_92_1040# m1_92_496#
+ li_2605_3145# sky130_fd_sc_hd__and3_1
X_221_ VSUBS li_5365_12053# m1_92_496# li_3801_11101# li_5871_12121# li_4629_10693#
+ m1_92_496# m1_92_1040# li_5550_12189# li_2237_11033# sky130_fd_sc_hd__a32o_1
XFILLER_12_50 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_6
XFILLER_10_110 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
X_152_ VSUBS m1_92_496# li_3893_3009# m1_92_1040# li_3801_2873# m1_92_496# sky130_fd_sc_hd__inv_2
XFILLER_17_17 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_3_139 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
X_204_ VSUBS li_4721_1989# li_3893_3009# li_4169_1309# m1_92_496# m1_92_1040# m1_92_496#
+ li_4905_1921# li_3617_1853# sky130_fd_sc_hd__a31oi_2
XFILLER_9_95 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_22_3 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_6
XPHY_28 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_3
XPHY_17 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_3
XFILLER_6_41 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XPHY_39 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_3
XFILLER_15_94 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_11_19 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_8
XFILLER_22_141 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_13_163 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
X_297_ VSUBS li_10057_6137# m1_92_1040# m1_92_496# li_6653_1377# li_7573_7837# m1_92_496#
+ sky130_fd_sc_hd__nor2_2
X_220_ VSUBS li_7297_11645# m1_92_496# li_6929_11169# li_5871_12121# li_4629_10693#
+ m1_92_496# m1_92_1040# li_5550_12189# li_3801_11101# sky130_fd_sc_hd__a32o_1
XFILLER_10_122 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_6_115 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
X_151_ VSUBS m1_92_496# li_4169_1309# m1_92_1040# li_4077_1377# m1_92_496# sky130_fd_sc_hd__inv_2
XFILLER_3_118 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_0_76 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_0_54 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_9_30 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_6
X_203_ VSUBS li_6929_4573# li_3525_1309# m1_92_496# li_2605_3145# li_6745_4641# m1_92_496#
+ li_6837_4641# m1_92_1040# sky130_fd_sc_hd__a31o_1
XFILLER_15_3 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_6_97 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_6_53 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_6_75 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XPHY_29 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_3
XPHY_18 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_3
XFILLER_17_128 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_12
XFILLER_15_73 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_22_164 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
X_296_ VSUBS li_6009_5661# li_1133_3009# m1_92_496# m1_92_1040# li_581_2805# li_1317_3009#
+ m1_92_496# li_7205_5661# li_2973_5117# sky130_fd_sc_hd__o221ai_1
XFILLER_3_87 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_3_54 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_10_156 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
X_150_ VSUBS li_2973_5117# li_4721_4097# li_489_6069# m1_92_1040# m1_92_496# li_3709_5253#
+ m1_92_496# sky130_fd_sc_hd__or3_4
X_279_ VSUBS m1_92_496# li_11253_10625# m1_92_1040# li_11161_10421# m1_92_496# sky130_fd_sc_hd__inv_2
X_202_ VSUBS li_9229_4505# m1_92_496# li_6837_2397# li_7205_5661# li_9137_2601# m1_92_496#
+ m1_92_1040# li_9321_833# li_8677_2533# sky130_fd_sc_hd__a32o_1
XFILLER_0_88 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_8
XPHY_19 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_3
Xoutput40 VSUBS m1_92_496# li_14933_6409# m1_92_496# li_15117_8857# m1_92_1040# sky130_fd_sc_hd__clkbuf_2
XFILLER_15_30 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_6
Xoutput5 VSUBS li_10057_6137# li_15117_2601# m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__buf_1
XFILLER_3_11 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
X_295_ VSUBS li_5641_4641# li_4721_10625# li_4905_1921# li_1317_3009# m1_92_496# m1_92_1040#
+ li_2973_5117# m1_92_496# li_581_2805# sky130_fd_sc_hd__o2111a_1
X_278_ VSUBS li_6929_11169# li_11253_10625# li_949_11101# m1_92_1040# m1_92_496# m1_92_496#
+ sky130_fd_sc_hd__or2_1
X_347_ VSUBS li_9505_7293# m1_92_496# m1_92_1040# m1_92_496# li_7573_11713# li_7297_12121#
+ li_8677_8517# sky130_fd_sc_hd__dfrtp_1
X_201_ VSUBS m1_92_496# li_6837_4641# m1_92_496# li_7205_5661# m1_92_1040# sky130_fd_sc_hd__clkbuf_2
XFILLER_2_164 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_9_87 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_9_43 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
XFILLER_15_42 VSUBS m1_92_1040# m1_92_496# m1_92_496# sky130_fd_sc_hd__decap_4
Xoutput6 VSUBS m1_92_496# li_1133_1241# m1_92_496# li_949_1241# m1_92_1040# sky130_fd_sc_hd__clkbuf_2
Xoutput41 VSUBS m1_92_496# li_857_4505# m1_92_496# li_673_4505# m1_92_1040# sky130_fd_sc_hd__clkbuf_2
Xoutput30 VSUBS m1_92_496# li_949_5593# m1_92_496# li_765_5593# m1_92_1040# sky130_fd_sc_hd__clkbuf_2
.ends

.subckt SAR VSUBS m5_23740_226# m3_0_16239# m5_22661_2229# m4_0_3622# m3_0_15119#
+ m3_0_16099# m4_66880_8257# m3_0_16519# m3_0_16379# m4_66880_23721# m3_0_15259# m4_0_226#
+ m3_0_16659# m3_0_15539# m3_0_15399# m3_0_15819# m3_0_16799# m3_0_15679# m3_0_15959#
Xlatch_0 VSUBS m5_22661_2229# m2_19196_16639# m1_20945_14806# m1_20945_17139# m5_23740_226#
+ latch
XDAC_0 VSUBS m2_10004_23121# m2_4024_23121# m2_13960_23121# m4_25852_17371# m3_2844_5767#
+ m2_5956_23121# m5_23740_226# m5_22661_2229# m2_15984_23121# m2_12028_23121# m5_22661_2229#
+ m5_23740_226# m4_66880_23721# m2_7980_23121# m5_23740_226# m5_22661_2229# m2_18008_23121#
+ DAC
XDAC_1 VSUBS m2_10004_7660# m2_4024_6832# m2_13960_8212# m4_25852_14667# m3_2844_5767#
+ m2_5956_7108# m5_23740_226# m5_22661_2229# m2_15984_8488# m2_12028_7936# m5_22661_2229#
+ m5_22661_2229# m4_66880_8257# m2_7980_7384# m5_23740_226# m5_22661_2229# m2_18008_8764#
+ DAC
Xcomparator_0 VSUBS m5_23740_226# m2_19216_12015# m2_19216_20175# m1_20945_17139#
+ m2_19216_21263# m4_25852_17371# m2_19216_22487# m1_19196_15415# m5_22661_2229# m4_25852_14667#
+ m2_19216_13103# m2_19216_18951# m2_19216_14327# m2_19216_9703# m1_20945_14806# m2_19216_10791#
+ m2_19216_17863# comparator
Xsarlogic_0 VSUBS m2_12028_23121# m3_0_16099# m2_19216_13103# m2_19216_20175# m2_19216_18951#
+ m4_0_226# m3_0_16519# m3_0_16239# m2_5956_7108# m4_0_3622# m2_19196_16639# m2_10004_23121#
+ m3_0_15959# m2_18008_23121# m3_0_15399# m3_0_16659# m3_0_15819# m2_18008_8764# m3_0_15679#
+ m3_0_16799# m2_19216_22487# m3_0_16379# m2_19216_9703# m2_19216_17863# m3_0_15539#
+ m1_19196_15415# m2_12028_7936# m2_7980_7384# m2_7980_23121# m2_5956_23121# m2_19216_14327#
+ m2_13960_8212# m2_13960_23121# m2_15984_8488# m2_15984_23121# m3_0_15119# m2_19216_21263#
+ m2_10004_7660# m2_19216_10791# m2_4024_6832# m3_2844_5767# m2_4024_23121# m2_19216_12015#
+ m3_0_15259# sarlogic
.ends

.subckt MNG VSUBS w_n1084_n157# a_n1058_n131# a_1000_n131# a_n1000_n157#
X0 a_1000_n131# a_n1000_n157# a_n1058_n131# VSUBS sky130_fd_pr__nfet_01v8 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=1e+07u
.ends

.subckt MDUM VSUBS a_n1058_n100# a_1000_n100# a_n1000_n126# w_n1084_n126#
X0 a_1000_n100# a_n1000_n126# a_n1058_n100# VSUBS sky130_fd_pr__nfet_01v8 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=1e+07u
.ends

.subckt MN VSUBS a_n1058_n100# a_1000_n100# a_n1000_n126# w_n1084_n126#
X0 a_1000_n100# a_n1000_n126# a_n1058_n100# VSUBS sky130_fd_pr__nfet_01v8 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=1e+07u
.ends

.subckt diode_unit VSUBS MN_1/w_n1084_n126# MN_1/a_n1000_n126# MN_0/a_n1058_n100#
+ MN_0/a_n1000_n126# MN_0/a_1000_n100# MN_1/a_1000_n100#
XMN_0 VSUBS MN_0/a_n1058_n100# MN_0/a_1000_n100# MN_0/a_n1000_n126# MN_1/w_n1084_n126#
+ MN
XMN_1 VSUBS MN_0/a_1000_n100# MN_1/a_1000_n100# MN_1/a_n1000_n126# MN_1/w_n1084_n126#
+ MN
.ends

.subckt cmirr VSUBS m3_0_336# m3_0_5039#
XMNG_3 VSUBS MNG_4/w_n1084_n157# VSUBS VSUBS m3_0_336# MNG
XMNG_4 VSUBS MNG_4/w_n1084_n157# VSUBS VSUBS VSUBS MNG
XMDUM_0 VSUBS VSUBS VSUBS m3_0_336# MDUM_7/w_n1084_n126# MDUM
XMNG_5 VSUBS MNG_9/w_n1084_n157# VSUBS VSUBS VSUBS MNG
XMDUM_1 VSUBS m3_0_336# m3_0_336# VSUBS MN_1/w_n1084_n126# MDUM
XMNG_6 VSUBS MNG_9/w_n1084_n157# VSUBS VSUBS m3_0_336# MNG
XMDUM_2 VSUBS VSUBS VSUBS m3_0_336# MDUM_9/w_n1084_n126# MDUM
XMNG_7 VSUBS MNG_9/w_n1084_n157# VSUBS VSUBS m3_0_336# MNG
XMDUM_3 VSUBS VSUBS VSUBS m3_0_336# MDUM_9/w_n1084_n126# MDUM
XMNG_8 VSUBS MNG_9/w_n1084_n157# VSUBS VSUBS m3_0_336# MNG
XMDUM_4 VSUBS VSUBS VSUBS VSUBS MDUM_9/w_n1084_n126# MDUM
XMNG_9 VSUBS MNG_9/w_n1084_n157# VSUBS VSUBS VSUBS MNG
XMDUM_5 VSUBS VSUBS VSUBS VSUBS MDUM_7/w_n1084_n126# MDUM
XMDUM_6 VSUBS VSUBS VSUBS m3_0_336# MDUM_7/w_n1084_n126# MDUM
XMDUM_7 VSUBS VSUBS VSUBS m3_0_336# MDUM_7/w_n1084_n126# MDUM
XMDUM_8 VSUBS m3_0_5039# m3_0_5039# VSUBS MN_1/w_n1084_n126# MDUM
XMDUM_9 VSUBS VSUBS VSUBS m3_0_336# MDUM_9/w_n1084_n126# MDUM
XMN_0 VSUBS m3_0_336# m3_0_336# m3_0_336# MN_1/w_n1084_n126# MN
XMN_1 VSUBS m3_0_5039# VSUBS m3_0_336# MN_1/w_n1084_n126# MN
XMN_2 VSUBS m3_0_5039# VSUBS m3_0_336# MN_4/w_n1084_n126# MN
XMN_3 VSUBS m3_0_336# m3_0_336# m3_0_336# MN_5/w_n1084_n126# MN
XMN_4 VSUBS m3_0_336# m3_0_336# m3_0_336# MN_4/w_n1084_n126# MN
XMN_5 VSUBS VSUBS m3_0_5039# m3_0_336# MN_5/w_n1084_n126# MN
XMDUM_30 VSUBS VSUBS VSUBS m3_0_336# MDUM_9/w_n1084_n126# MDUM
XMN_6 VSUBS m3_0_336# m3_0_336# m3_0_336# MN_7/w_n1084_n126# MN
XMN_7 VSUBS VSUBS m3_0_5039# m3_0_336# MN_7/w_n1084_n126# MN
XMDUM_31 VSUBS m3_0_5039# m3_0_5039# VSUBS MN_7/w_n1084_n126# MDUM
XMDUM_20 VSUBS VSUBS VSUBS VSUBS MDUM_27/w_n1084_n126# MDUM
Xdiode_unit_0 VSUBS MN_4/w_n1084_n126# m3_0_336# VSUBS m3_0_336# m1_6977_2255# m3_0_336#
+ diode_unit
XMDUM_21 VSUBS m3_0_5039# m3_0_5039# VSUBS MN_5/w_n1084_n126# MDUM
XMDUM_10 VSUBS VSUBS VSUBS VSUBS MDUM_9/w_n1084_n126# MDUM
Xdiode_unit_1 VSUBS MN_5/w_n1084_n126# m3_0_336# m3_0_336# m3_0_336# m1_6977_2255#
+ VSUBS diode_unit
XMDUM_22 VSUBS m3_0_336# m3_0_336# VSUBS MN_4/w_n1084_n126# MDUM
XMDUM_11 VSUBS VSUBS VSUBS VSUBS MDUM_7/w_n1084_n126# MDUM
Xdiode_unit_2 VSUBS MN_5/w_n1084_n126# m3_0_336# m3_0_336# m3_0_336# m1_6977_2255#
+ VSUBS diode_unit
XMDUM_23 VSUBS VSUBS VSUBS m3_0_336# MDUM_27/w_n1084_n126# MDUM
XMDUM_12 VSUBS VSUBS VSUBS m3_0_336# MDUM_27/w_n1084_n126# MDUM
Xdiode_unit_3 VSUBS MN_1/w_n1084_n126# m3_0_336# VSUBS m3_0_336# m1_6977_2255# m3_0_336#
+ diode_unit
XMNG_10 VSUBS MNG_9/w_n1084_n157# VSUBS VSUBS m3_0_336# MNG
XMDUM_24 VSUBS VSUBS VSUBS m3_0_336# MDUM_27/w_n1084_n126# MDUM
XMDUM_13 VSUBS VSUBS VSUBS VSUBS MDUM_27/w_n1084_n126# MDUM
Xdiode_unit_4 VSUBS MN_7/w_n1084_n126# m3_0_336# m3_0_336# m3_0_336# m1_6977_2255#
+ VSUBS diode_unit
XMNG_11 VSUBS MNG_4/w_n1084_n157# VSUBS VSUBS m3_0_336# MNG
XMDUM_25 VSUBS VSUBS VSUBS m3_0_336# MDUM_26/w_n1084_n126# MDUM
XMDUM_14 VSUBS m3_0_336# m3_0_336# VSUBS MN_5/w_n1084_n126# MDUM
Xdiode_unit_5 VSUBS MN_1/w_n1084_n126# m3_0_336# VSUBS m3_0_336# m1_6977_2255# m3_0_336#
+ diode_unit
XMDUM_26 VSUBS VSUBS VSUBS m3_0_336# MDUM_26/w_n1084_n126# MDUM
XMDUM_15 VSUBS VSUBS VSUBS VSUBS MDUM_26/w_n1084_n126# MDUM
XMDUM_27 VSUBS VSUBS VSUBS m3_0_336# MDUM_27/w_n1084_n126# MDUM
XMDUM_16 VSUBS VSUBS VSUBS m3_0_336# MDUM_26/w_n1084_n126# MDUM
XMDUM_28 VSUBS VSUBS VSUBS m3_0_336# MDUM_7/w_n1084_n126# MDUM
XMDUM_17 VSUBS m3_0_5039# m3_0_5039# VSUBS MN_4/w_n1084_n126# MDUM
XMDUM_29 VSUBS m3_0_336# m3_0_336# VSUBS MN_7/w_n1084_n126# MDUM
XMDUM_18 VSUBS VSUBS VSUBS VSUBS MDUM_26/w_n1084_n126# MDUM
XMDUM_19 VSUBS VSUBS VSUBS m3_0_336# MDUM_26/w_n1084_n126# MDUM
XMNG_0 VSUBS MNG_4/w_n1084_n157# VSUBS VSUBS m3_0_336# MNG
XMNG_1 VSUBS MNG_4/w_n1084_n157# VSUBS VSUBS VSUBS MNG
XMNG_2 VSUBS MNG_4/w_n1084_n157# VSUBS VSUBS m3_0_336# MNG
.ends

.subckt user_analog_project_wrapper wb_clk_i wb_rst_i wbs_ack_o wbs_adr_i[0] wbs_adr_i[10]
+ wbs_adr_i[11] wbs_adr_i[12] wbs_adr_i[13] wbs_adr_i[14] wbs_adr_i[15] wbs_adr_i[16]
+ wbs_adr_i[17] wbs_adr_i[1] wbs_adr_i[2] wbs_adr_i[3] wbs_adr_i[4] wbs_adr_i[5] wbs_adr_i[6]
+ wbs_adr_i[7] wbs_adr_i[8] wbs_adr_i[9] wbs_cyc_i wbs_dat_i[0] wbs_dat_i[10] wbs_dat_i[11]
+ wbs_dat_i[12] wbs_dat_i[13] wbs_dat_i[14] wbs_dat_i[15] wbs_dat_i[16] wbs_dat_i[1]
+ wbs_dat_i[2] wbs_dat_i[3] wbs_dat_i[4] wbs_dat_i[5] wbs_dat_i[6] wbs_dat_i[7] wbs_dat_i[8]
+ wbs_dat_i[9] wbs_dat_o[0] wbs_dat_o[10] wbs_dat_o[11] wbs_dat_o[12] wbs_dat_o[13]
+ wbs_dat_o[14] wbs_dat_o[15] wbs_dat_o[16] wbs_dat_o[1] wbs_dat_o[2] wbs_dat_o[3]
+ wbs_dat_o[4] wbs_dat_o[5] wbs_dat_o[6] wbs_dat_o[7] wbs_dat_o[8] wbs_dat_o[9] wbs_sel_i[0]
+ wbs_sel_i[1] wbs_sel_i[2] wbs_sel_i[3] wbs_stb_i wbs_we_i wbs_dat_i[17] wbs_dat_i[18]
+ wbs_dat_i[19] wbs_adr_i[18] wbs_dat_i[20] wbs_dat_i[21] wbs_dat_i[22] wbs_dat_i[23]
+ wbs_dat_i[24] wbs_dat_i[25] wbs_dat_i[26] wbs_dat_i[27] wbs_dat_i[28] wbs_dat_i[29]
+ wbs_adr_i[19] wbs_dat_i[30] wbs_dat_i[31] la_oenb[0] wbs_adr_i[20] wbs_adr_i[21]
+ wbs_adr_i[22] wbs_adr_i[23] wbs_adr_i[24] wbs_adr_i[25] wbs_adr_i[26] wbs_adr_i[27]
+ wbs_adr_i[28] wbs_adr_i[29] la_oenb[1] wbs_adr_i[30] wbs_adr_i[31] la_oenb[2] wbs_dat_o[17]
+ wbs_dat_o[18] wbs_dat_o[19] la_oenb[3] wbs_dat_o[20] wbs_dat_o[21] wbs_dat_o[22]
+ wbs_dat_o[23] wbs_dat_o[24] wbs_dat_o[25] wbs_dat_o[26] wbs_dat_o[27] wbs_dat_o[28]
+ wbs_dat_o[29] la_oenb[4] wbs_dat_o[30] wbs_dat_o[31] la_oenb[5] la_data_in[0] la_data_in[1]
+ la_data_in[2] la_data_in[3] la_data_in[4] la_data_in[5] la_data_out[0] la_data_out[1]
+ la_data_out[2] la_data_out[3] la_data_out[4] la_data_out[5] la_data_in[23] la_data_in[24]
+ la_data_in[25] la_oenb[6] la_oenb[7] la_oenb[8] la_oenb[9] la_data_in[26] la_data_in[11]
+ la_data_in[12] la_data_in[13] la_data_in[14] la_data_in[6] la_data_in[7] la_data_in[8]
+ la_data_in[9] la_data_in[15] la_data_out[10] la_data_out[11] la_data_out[12] la_data_out[13]
+ la_data_out[14] la_data_out[15] la_data_out[16] la_data_out[17] la_data_out[18]
+ la_data_out[19] la_data_in[16] la_data_out[20] la_data_out[21] la_data_out[22] la_data_out[23]
+ la_data_out[24] la_data_out[25] la_data_in[17] la_data_in[18] la_data_in[19] la_data_in[10]
+ la_data_out[6] la_data_out[7] la_data_out[8] la_data_out[9] la_data_in[20] la_oenb[10]
+ la_oenb[11] la_oenb[12] la_oenb[13] la_oenb[14] la_oenb[15] la_oenb[16] la_oenb[17]
+ la_oenb[18] la_oenb[19] la_data_in[21] la_oenb[20] la_oenb[21] la_oenb[22] la_oenb[23]
+ la_oenb[24] la_oenb[25] la_data_in[22] la_data_in[39] la_oenb[45] la_data_in[40]
+ la_data_out[26] la_data_out[27] la_data_out[28] la_data_out[29] la_data_in[41] la_data_out[30]
+ la_data_out[31] la_data_out[32] la_data_out[33] la_data_out[34] la_data_out[35]
+ la_data_out[36] la_data_out[37] la_data_out[38] la_data_out[39] la_data_in[42] la_data_out[40]
+ la_data_out[41] la_data_out[42] la_data_out[43] la_data_out[44] la_data_out[45]
+ la_data_out[46] la_data_in[43] la_data_in[44] la_data_in[45] la_data_in[46] la_oenb[46]
+ la_oenb[38] la_oenb[39] la_oenb[37] la_oenb[40] la_oenb[41] la_oenb[42] la_oenb[43]
+ la_data_in[27] la_data_in[28] la_data_in[29] la_oenb[44] la_data_in[30] la_data_in[31]
+ la_data_in[32] la_data_in[33] la_data_in[34] la_data_in[35] la_data_in[36] la_data_in[37]
+ la_oenb[26] la_oenb[27] la_oenb[28] la_oenb[29] la_data_in[38] la_oenb[30] la_oenb[31]
+ la_oenb[32] la_oenb[33] la_oenb[34] la_oenb[35] la_oenb[36] la_oenb[47] la_oenb[48]
+ la_oenb[49] la_oenb[50] la_oenb[51] la_oenb[52] la_oenb[53] la_oenb[54] la_oenb[55]
+ la_oenb[56] la_oenb[57] la_oenb[58] la_oenb[59] la_oenb[60] la_oenb[61] la_oenb[62]
+ la_oenb[63] la_oenb[64] la_oenb[65] la_oenb[66] la_data_in[47] la_data_in[48] la_data_in[49]
+ la_data_in[50] la_data_in[51] la_data_in[52] la_data_in[53] la_data_in[54] la_data_in[55]
+ la_data_in[56] la_data_in[57] la_data_in[58] la_data_in[59] la_data_in[60] la_data_in[61]
+ la_data_in[62] la_data_in[63] la_data_out[47] la_data_out[48] la_data_out[49] la_data_in[64]
+ la_data_out[50] la_data_out[51] la_data_out[52] la_data_out[53] la_data_out[54]
+ la_data_out[55] la_data_out[56] la_data_out[57] la_data_out[58] la_data_out[59]
+ la_data_in[65] la_data_out[60] la_data_out[61] la_data_out[62] la_data_out[63] la_data_out[64]
+ la_data_out[65] la_data_out[66] la_data_out[67] la_data_in[66] la_data_in[67] la_data_in[72]
+ la_data_in[73] la_data_in[74] la_data_in[75] la_data_in[76] la_data_in[77] la_data_in[78]
+ la_data_in[79] la_data_in[80] la_data_in[81] la_data_in[82] la_data_in[83] la_data_in[84]
+ la_data_in[85] la_data_in[86] la_data_in[87] la_data_in[69] la_oenb[67] la_oenb[68]
+ la_oenb[69] la_oenb[70] la_oenb[71] la_oenb[72] la_oenb[73] la_oenb[74] la_oenb[75]
+ la_oenb[76] la_oenb[77] la_oenb[78] la_oenb[79] la_oenb[80] la_oenb[81] la_oenb[82]
+ la_oenb[83] la_oenb[84] la_oenb[85] la_oenb[86] la_oenb[87] la_data_out[68] la_data_out[69]
+ la_data_in[70] la_data_out[70] la_data_out[71] la_data_out[72] la_data_out[73] la_data_out[74]
+ la_data_out[75] la_data_out[76] la_data_out[77] la_data_out[78] la_data_out[79]
+ la_data_in[71] la_data_out[80] la_data_out[81] la_data_out[82] la_data_out[83] la_data_out[84]
+ la_data_out[85] la_data_out[86] la_data_out[87] la_data_in[68] la_oenb[88] la_oenb[89]
+ la_oenb[90] la_oenb[91] la_oenb[92] la_oenb[93] la_oenb[94] la_oenb[95] la_oenb[96]
+ la_oenb[97] la_oenb[98] la_oenb[99] la_data_in[101] la_data_in[102] la_data_in[103]
+ la_data_in[104] la_data_in[105] la_data_in[106] la_data_in[107] la_data_in[108]
+ la_data_in[100] la_data_in[90] la_data_in[91] la_data_in[92] la_data_in[93] la_data_in[94]
+ la_data_in[95] la_data_in[96] la_data_in[97] la_data_in[98] la_data_in[99] la_data_out[100]
+ la_data_out[101] la_data_out[102] la_data_out[103] la_data_out[104] la_data_out[105]
+ la_data_out[93] la_data_out[106] la_data_out[94] la_data_out[107] la_data_out[95]
+ la_data_out[96] la_data_out[108] la_data_out[97] la_data_out[98] la_data_out[99]
+ la_data_out[92] la_oenb[100] la_oenb[101] la_oenb[102] la_oenb[103] la_oenb[104]
+ la_oenb[105] la_oenb[106] la_oenb[107] la_data_in[88] la_data_in[89] la_data_out[88]
+ la_data_out[89] la_data_out[90] la_data_out[91] la_data_in[119] la_data_out[120]
+ la_data_out[121] la_data_out[122] la_data_in[116] la_data_in[117] la_data_out[123]
+ la_data_in[112] la_data_out[124] la_data_out[125] la_data_out[126] la_data_out[127]
+ la_data_in[118] la_oenb[109] la_data_in[120] la_oenb[110] la_data_in[121] la_oenb[111]
+ la_oenb[112] la_oenb[113] la_oenb[114] la_oenb[115] la_oenb[116] la_oenb[117] la_oenb[118]
+ la_oenb[119] la_data_in[122] la_data_in[123] la_oenb[120] la_oenb[121] la_oenb[122]
+ la_oenb[123] la_oenb[124] la_oenb[125] la_oenb[126] la_oenb[127] la_data_in[124]
+ la_data_in[125] la_data_in[126] la_data_in[127] la_data_out[110] user_clock2 user_irq[0]
+ la_data_in[113] user_irq[1] la_data_in[114] user_irq[2] la_data_out[111] la_data_out[112]
+ la_data_out[109] la_data_in[109] la_data_out[113] la_data_in[110] la_data_out[114]
+ la_oenb[108] la_data_out[115] la_data_out[116] la_data_in[111] la_data_out[117]
+ la_data_in[115] la_data_out[118] la_data_out[119] io_analog[4] io_analog[5] io_analog[6]
+ gpio_analog[2] gpio_analog[3] gpio_analog[4] gpio_analog[5] gpio_analog[6] gpio_noesd[2]
+ gpio_noesd[3] gpio_noesd[4] gpio_noesd[5] gpio_noesd[6] io_analog[0] io_analog[1]
+ io_analog[2] io_analog[3] io_clamp_high[0] io_clamp_low[0] io_in[10] io_in[11] io_in[12]
+ io_in[13] io_in[9] io_in_3v3[10] io_in_3v3[11] io_in_3v3[12] io_in_3v3[13] io_in_3v3[9]
+ io_oeb[10] io_oeb[11] io_oeb[12] io_oeb[13] io_oeb[9] io_out[10] io_out[11] io_out[12]
+ io_out[13] io_out[9] vccd1 vdda1 vssa1 io_in[16] io_in[17] gpio_analog[9] gpio_noesd[10]
+ io_analog[7] io_in_3v3[14] io_in_3v3[15] io_in_3v3[16] io_in_3v3[17] io_analog[8]
+ io_analog[9] gpio_noesd[7] io_oeb[14] io_oeb[15] io_oeb[16] io_oeb[17] gpio_noesd[8]
+ io_clamp_high[1] io_clamp_high[2] gpio_noesd[9] io_clamp_low[1] io_out[14] io_out[15]
+ io_out[16] io_out[17] io_clamp_low[2] gpio_analog[10] io_analog[10] vccd2 gpio_analog[7]
+ gpio_analog[8] io_in[14] io_in[15] vssa2 io_in_3v3[24] io_in_3v3[25] io_in_3v3[26]
+ gpio_analog[16] gpio_analog[17] gpio_analog[11] gpio_analog[12] gpio_noesd[11] io_in[18]
+ io_in[19] io_in[20] io_in[21] io_oeb[18] io_oeb[19] io_oeb[20] io_oeb[21] io_oeb[22]
+ io_oeb[23] io_oeb[24] io_oeb[25] io_oeb[26] io_in[22] io_in[23] io_in[24] io_in[25]
+ io_in[26] gpio_noesd[12] gpio_noesd[13] gpio_noesd[14] gpio_noesd[15] io_out[18]
+ io_out[19] io_out[20] io_out[21] io_out[22] io_out[23] io_out[24] io_out[25] io_out[26]
+ gpio_noesd[16] gpio_noesd[17] gpio_analog[13] gpio_analog[14] gpio_analog[15] io_in_3v3[18]
+ io_in_3v3[19] vdda2 io_in_3v3[20] io_in_3v3[21] io_in_3v3[22] io_in_3v3[23] vssd2
+ io_in_3v3[6] io_in_3v3[7] io_in_3v3[8] io_in[1] io_oeb[0] gpio_noesd[0] io_in[2]
+ io_in[3] io_in[4] io_in[5] io_out[1] io_in[6] io_in_3v3[1] io_in[7] io_in[8] gpio_analog[0]
+ io_oeb[1] io_in_3v3[0] io_out[2] io_out[3] io_out[4] io_out[5] io_out[6] io_out[7]
+ io_out[8] gpio_analog[1] gpio_noesd[1] io_in[0] io_in_3v3[2] io_in_3v3[3] io_in_3v3[4]
+ io_oeb[2] io_oeb[3] io_oeb[4] io_oeb[5] io_oeb[6] io_oeb[7] io_oeb[8] vssd1 io_in_3v3[5]
+ io_out[0]
Xmain_0 vssa1 io_out[12] la_data_in[103] la_data_in[100] la_data_in[106] la_data_in[101]
+ io_analog[2] io_analog[1] io_in[11] m3_416017_689925# vssa1 la_data_in[104] vdda1
+ la_data_in[105] la_data_in[102] io_analog[0] main
XSAR_0 vssa1 vdda1 la_data_out[33] vssa1 vccd2 io_in[21] la_data_out[34] io_analog[4]
+ la_data_out[31] la_data_out[32] io_analog[5] io_in[20] vssd2 la_data_out[30] io_in[18]
+ io_in[19] la_data_out[36] la_data_out[29] io_out[17] la_data_out[35] SAR
Xcmirr_0 vssa1 m3_416017_689925# io_analog[3] cmirr
.ends
